BATCH MODE INSTRUCTIONS ...............                                                             
Batch for preparing the Pitch Shuttle Ascent Models at First Stage Max-Q, T=61 sec
! This batch set creates Pitch Shuttle Ascent models at Max Dynamic Pressure. The models are
! used for H-infinity control design to reduce the sideslip sensitivity to gusts. The average
! wind-gust frequencies are at around 1 (rad/sec). The batch creates an H-infinity synthesis
! model and a stability/sensitivity analysis model. The SM is augmented with 2 additional states
! to capture the 1 (r/s) resonance. The analysis model includes the actuators, sensors, TWD
! dynamics and the load-torque feedback. The actuator and sensor subsystems were calculated from
! previous analysis and retained in the systems file together with the TVC matrix. Different 
! versions of the vehicle model are calculated. Flex is not included.
!
Retain Matrix    : Shuttle Stage-1 TVC Matrix at Max-Q
Retain Matrix    : Shuttle Stage-1 TVC Matrix with Gust input
Retain System    : System of Five Actuators
Retain System    : IMU, Gyro, Accelerometer Sensors
To Matlab Format : Shuttle Stage-1 TVC Matrix at Max-Q
!
Flight Vehicle   : Shuttle Ascent, Max_Q, T=61 sec, (Design Model)                
Flight Vehicle   : Shuttle Ascent, Max_Q, T=61 sec, Rigid-Body/ Slosh Analysis Model          
Flight Vehicle   : Shuttle Ascent, Max_Q, T=61 sec, Rigid-Body/ Slosh/ TWD/ Acceleromet          
!
System Connection: Shuttle Ascent, Max_Q, Design Model with TVC  
System Modificat : Shuttle Ascent, Max_Q, Pitch Hinf Design Model
To Matlab Format : Shuttle Ascent, Max_Q, Pitch Hinf Design Model
!
System Connection: Shuttle Ascent, Max_Q, Analysis Model with Slosh & TVC
System Modificat : Shuttle Ascent, Max_Q, Pitch Analysis with Slosh & TVC
To Matlab Format : Shuttle Ascent, Max_Q, Pitch Analysis with Slosh & TVC
!
System Connection: Shuttle Plant Model at Max-Q (Flex Vehicle, Actuators, Sensors)
To Matlab Format : Shuttle Plant Model at Max-Q (Flex Vehicle, Actuators, Sensors)
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Shuttle Ascent, Max_Q, T=61 sec, (Design Model)
! Rigid Body Shuttle Design Model during First Stage at Max Dynamic Pressure. 
! Slosh, Bending, and Tail-Wag-Dog are Not Included.
Body Axes Output, Attitude=Rate Integral,Without GAFD, No Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Planet Radius (Re) (ft)   :   93215.0      32.174       0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   0.248524E+8  0.209190E+9  0.221208E+9, 0.0, 0.937592E+7, 0.0    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -115.0        0.036       -35.937
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   1.54         1518.0       745.4        39410.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   33.0         60.45        0.0          7.45    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  -3.579       -0.04         0.0          0.0    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0000       57.93        0.0000       0.0000       0.0000       0.0000    
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:   Gust         45.0         90.0    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   2690.0       15.0         15.0  
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -115.0        0.036       -35.937      -9.482e-10
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.0          0.0          0.0          0.0          0.0          0.0000       0.0000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0         -0.0353       0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:   0.0         -0.0575       0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.0         -0.028        0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:   0.0         -0.017        0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0          0.0249       0.0000       0.0000       0.0000       0.0000    

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  0   NO TWD  

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  5   NO TWD

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Middle SSME      Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  472000.0     472000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -16.0         0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  220.0        4800.0        3.1   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -182.1667     0.0          -64.958
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : Left SSME        Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  472000.0     472000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -10.0         0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  220.0        4800.0        3.1   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -184.1       -4.4167       -56.595    
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : Right SSME       Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  472000.0     472000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -10.0         0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  220.0        4800.0        3.1   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -184.1        4.4167       -56.595    
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : Left SRB         Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.245e+7     0.245e+7
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0          0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  605.0        0.154e+5     -1.07   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -201.53      -20.875       -33.3333    
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : Left SRB         Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.245e+7     0.245e+7
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0          0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  605.0        0.154e+5     -1.07   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -201.53      +20.875       -33.3333

---------------------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Shuttle Ascent, Max_Q, Design Model with TVC
! Combines the Rigid vehicle model with the TVCG matrix that includes also the
! gust input. 
Titles of Systems to be Combined
Title 1 Shuttle Ascent, Max_Q, T=61 sec, (Design Model)
SYSTEM INPUTS TO SUBSYSTEM  1                                                        TVC to Vehicle
Via Matrix +TVCG                                                                     inputs: roll, pitch, yaw, gust
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                     from Plant
Via Matrix +I14                                                                      All Outputs
..............................................................................
Definitions of Inputs  =   4
DP_TVC (roll FCS demand)                                    
DQ_TVC (pitch FCS demand)          
DR_TVC (yaw FCS demand)                      
Wind Gust Azim, Elev Angles=(45, 90) (deg) 

Definitions of Outputs =  14
Roll Attitude  (phi-body) (radians)                                                          
Roll Rate      (p-body)   (rad/sec)                                                          
Pitch Attitude (thet-bdy) (radians)                                                          
Pitch Rate     (q-body)   (rad/sec)                                                          
Yaw  Attitude  (psi-body) (radians)                                                          
Yaw  Rate      (r-body)   (rad/sec)                                                          
Angle of attack, alfa, (radians)                                                             
Angle of sideslip, beta, (radian)                                                            
Change in Altitude, delta-h, (feet)                                                          
Forward Acceleration  (V-dot)  (ft/sec)                                                      
Cross Range Velocity (Vcr) (ft/sec)                                                          
CG Acceleration along X axis, (ft/sec^2)                                                     
CG Acceleration along Y axis, (ft/sec^2)                                                     
CG Acceleration along Z axis, (ft/sec^2)                                                     
---------------------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Shuttle Ascent, Max_Q, Pitch Hinf Design Model
Shuttle Ascent, Max_Q, Design Model with TVC
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   2  4 
Extract States :   3  4  7 
Extract Outputs:   3  4  7 
---------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Shuttle Ascent, Max_Q, T=61 sec, Rigid-Body/ Slosh Analysis Model
! Rigid Body Shuttle Model during First Stage at Max Dynamic pressure. 
! Slosh is Included. No accelerometers.
Body Axes Output, Attitude=Rate Integral,Without GAFD, No Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Planet Radius (Re) (ft)   :   93215.0      32.174       0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   0.248524E+8  0.209190E+9  0.221208E+9, 0.0, 0.937592E+7, 0.0    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -115.0        0.036       -35.937
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   1.54         1518.0       745.4        39410.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   33.0         60.45        0.0          7.45    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  -3.579       -0.04         0.0          0.0    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0000       57.93        0.0000       0.0000       0.0000       0.0000    
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:   Gust         45.0         90.0    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   2690.0       15.0         15.0  
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -115.0        0.036       -35.937      -9.482e-10
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.0          0.0          0.0          0.0          0.0          0.0000       0.0000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0         -0.0353       0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:   0.0         -0.0575       0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.0         -0.028        0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:   0.0         -0.017        0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0          0.0249       0.0000       0.0000       0.0000       0.0000    

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  0   NO TWD  

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  5   NO TWD

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Middle SSME      Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  472000.0     472000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -16.0         0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  220.0        4800.0        3.1   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -182.1667     0.0          -64.958
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : Left SSME        Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  472000.0     472000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -10.0         0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  220.0        4800.0        3.1   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -184.1       -4.4167       -56.595    
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : Right SSME       Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  472000.0     472000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -10.0         0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  220.0        4800.0        3.1   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -184.1        4.4167       -56.595    
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : Left SRB         Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.245e+7     0.245e+7
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0          0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  605.0        0.154e+5     -1.07   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -201.53      -20.875       -33.3333    
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : Left SRB         Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.245e+7     0.245e+7
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0          0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  605.0        0.154e+5     -1.07   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -201.53      +20.875       -33.3333

Number of Slosh Modes                                                                    :  2
LOX Slosh Mass (slug), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft) :  4100.0  2.33  2.33  0.00164 0.00164 -57.96   0.0  -34.0    
LH2 Slosh Mass (slug), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft) :  512.5  2.066  2.066 0.00244 0.00244 -115.02  0.0  -34.29   

---------------------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Shuttle Ascent, Max_Q, Analysis Model with Slosh & TVC
! Combines the vehicle model w Slosh with the TVCG matrix that includes also the
! gust input. 
Titles of Systems to be Combined
Title 1 Shuttle Ascent, Max_Q, T=61 sec, Rigid-Body/ Slosh Analysis Model
SYSTEM INPUTS TO SUBSYSTEM  1                                                        TVC to Vehicle
Via Matrix +TVCG                                                                     inputs: roll, pitch, yaw, gust
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                     from Plant
Via Matrix +I14                                                                      All Outputs
..............................................................................
Definitions of Inputs  =   4
DP_TVC (roll FCS demand)                                    
DQ_TVC (pitch FCS demand)          
DR_TVC (yaw FCS demand)                      
Wind Gust Azim, Elev Angles=(45, 90) (deg) 

Definitions of Outputs =  14
Roll Attitude  (phi-body) (radians)                                                          
Roll Rate      (p-body)   (rad/sec)                                                          
Pitch Attitude (thet-bdy) (radians)                                                          
Pitch Rate     (q-body)   (rad/sec)                                                          
Yaw  Attitude  (psi-body) (radians)                                                          
Yaw  Rate      (r-body)   (rad/sec)                                                          
Angle of attack, alfa, (radians)                                                             
Angle of sideslip, beta, (radian)                                                            
Change in Altitude, delta-h, (feet)                                                          
Forward Acceleration  (V-dot)  (ft/sec)                                                      
Cross Range Velocity (Vcr) (ft/sec)                                                          
CG Acceleration along X axis, (ft/sec^2)                                                     
CG Acceleration along Y axis, (ft/sec^2)                                                     
CG Acceleration along Z axis, (ft/sec^2)                                                     
---------------------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Shuttle Ascent, Max_Q, Pitch Analysis with Slosh & TVC
Shuttle Ascent, Max_Q, Analysis Model with Slosh & TVC
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   2  4 
Extract States :   3  4  7  11  13  15  17
Extract Outputs:   3  4  7  14
---------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Shuttle Ascent, Max_Q, T=61 sec, Rigid-Body/ Slosh/ TWD/ Acceleromet
! Rigid Body Shuttle Model during First Stage at Max Dynamic pressure. 
! Slosh and Tail-Wag-Dog is Included.
Body Axes Output, Attitude=Rate Integral,Without GAFD, No Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Planet Radius (Re) (ft)   :   93215.0      32.174       0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   0.248524E+8  0.209190E+9  0.221208E+9, 0.0, 0.937592E+7, 0.0    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -115.0        0.036       -35.937
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   1.54         1518.0       745.4        39410.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   33.0         60.45        0.0          7.45    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  -3.579       -0.04         0.0          0.0    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0000       57.93        0.0000       0.0000       0.0000       0.0000    
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:   Gust         45.0         90.0    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   2690.0       15.0         15.0  
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -115.0        0.036       -35.937      -9.482e-10
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.0          0.0          0.0          0.0          0.0          0.0000       0.0000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0         -0.0353       0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:   0.0         -0.0575       0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.0         -0.028        0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:   0.0         -0.017        0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0          0.0249       0.0000       0.0000       0.0000       0.0000    

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  0   NO TWD  

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  5   WITH TWD

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Middle SSME      Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  472000.0     472000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -16.0         0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  220.0        4800.0        3.1   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -182.1667     0.0          -64.958
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : Left SSME        Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  472000.0     472000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -10.0         0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  220.0        4800.0        3.1   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -184.1       -4.4167       -56.595    
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : Right SSME       Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  472000.0     472000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -10.0         0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  220.0        4800.0        3.1   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -184.1        4.4167       -56.595    
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : Left SRB         Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.245e+7     0.245e+7
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0          0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  605.0        0.154e+5     -1.07   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -201.53      -20.875       -33.3333    
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : Left SRB         Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.245e+7     0.245e+7
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0          0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  605.0        0.154e+5     -1.07   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -201.53      +20.875       -33.3333

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Roll   Rate           -93.625     0.00    -61.5417    
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Pitch  Rate           -93.625     0.00    -61.5417
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Yaw    Rate           -93.625     0.00    -61.5417

Number of Accelerometers, Along Axis: (x,y,z)                                            :  2
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.     -93.625     0.00    -61.5417
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.     -93.625     0.00    -61.5417

Number of Slosh Modes                                                                    :  2
LOX Slosh Mass (slug), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft) :  4100.0  2.33  2.33  0.00164 0.00164 -57.96   0.0  -34.0    
LH2 Slosh Mass (slug), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft) :  512.5  2.066  2.066 0.00244 0.00244 -115.02  0.0  -34.29   

---------------------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Shuttle Plant Model at Max-Q (Flex Vehicle, Actuators, Sensors)
! Combine the above vehicle model with the Actuators and Sensors to create a fully coupled 
! pitch and lateral plant model. This system will be combined with the TVC and the 
! Flight Control System to create a simulation model. Tail-Wag-Dog and Load-Torque
! feedback interconnections are included.
!
Titles of Systems to be Combined
Title 1 Shuttle Ascent, Max_Q, T=61 sec, Rigid-Body/ Slosh/ TWD/ Acceleromet
Title 2 System of Five Actuators
Title 3 System of Five Actuators
Title 4 IMU, Gyro, Accelerometer Sensors
SYSTEM INPUTS TO SUBSYSTEM  1                                                        Wind to Vehicle
System Input 11 to Subsystem  1, Input 21, Gain= 1.0                                 Wind-Gust
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                        Pitch Deflection Commands
System Input  1 to Subsystem  2, Input  1, Gain= 1.0                                 dy1-com
System Input  2 to Subsystem  2, Input  2, Gain= 1.0                                 dy2-com
System Input  3 to Subsystem  2, Input  3, Gain= 1.0                                 dy3-com
System Input  4 to Subsystem  2, Input  4, Gain= 1.0                                 dy4-com
System Input  5 to Subsystem  2, Input  5, Gain= 1.0                                 dy5-com
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                                        Yaw Deflection Commands
System Input  6 to Subsystem  3, Input  1, Gain= 1.0                                 dz1-com
System Input  7 to Subsystem  3, Input  2, Gain= 1.0                                 dz2-com
System Input  8 to Subsystem  3, Input  3, Gain= 1.0                                 dz3-com
System Input  9 to Subsystem  3, Input  4, Gain= 1.0                                 dz4-com
System Input 10 to Subsystem  3, Input  5, Gain= 1.0                                 dz5-com
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  4                                                     Sensors
System Output  1 from Subsystem  4, Output  1, Gain= 1.0                             roll  attitude
System Output  2 from Subsystem  4, Output  2, Gain= 1.0                             pitch attitude
System Output  3 from Subsystem  4, Output  3, Gain= 1.0                             yaw   attitude
System Output  4 from Subsystem  4, Output  4, Gain= 1.0                             roll  rate
System Output  5 from Subsystem  4, Output  5, Gain= 1.0                             pitch rate
System Output  6 from Subsystem  4, Output  6, Gain= 1.0                             yaw   rate
System Output  7 from Subsystem  4, Output  7, Gain= 1.0                             Ny Accelerat
System Output  8 from Subsystem  4, Output  8, Gain= 1.0                             Nz Accelerat
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                     Vehicle Model
System Output  9 from Subsystem  1, Output  7, Gain= 1.00000                         alpha (rad)
System Output 10 from Subsystem  1, Output  8, Gain= 1.00000                         beta  (rad)
System Output 11 from Subsystem  1, Output 14, Gain= 1.00000                         TLY-1 (ft-lb)
System Output 12 from Subsystem  1, Output 15, Gain= 1.00000                         TLY-2 (ft-lb)
System Output 13 from Subsystem  1, Output 16, Gain= 1.00000                         TLY-3 (ft-lb)
System Output 14 from Subsystem  1, Output 17, Gain= 1.00000                         TLY-4 (ft-lb)
System Output 15 from Subsystem  1, Output 18, Gain= 1.00000                         TLY-5 (ft-lb)
System Output 16 from Subsystem  1, Output 19, Gain= 1.00000                         TLZ-1 (ft-lb)
System Output 17 from Subsystem  1, Output 20, Gain= 1.00000                         TLZ-2 (ft-lb)
System Output 18 from Subsystem  1, Output 21, Gain= 1.00000                         TLZ-3 (ft-lb)
System Output 19 from Subsystem  1, Output 22, Gain= 1.00000                         TLZ-4 (ft-lb)
System Output 20 from Subsystem  1, Output 23, Gain= 1.00000                         TLZ-5 (ft-lb)
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                     Pitch Actuator Model
System Output 21 from Subsystem  2, Output  1, Gain= 1.0                             dy-1
System Output 22 from Subsystem  2, Output  2, Gain= 1.0                             dy-2
System Output 23 from Subsystem  2, Output  3, Gain= 1.0                             dy-3
System Output 24 from Subsystem  2, Output  4, Gain= 1.0                             dy-4
System Output 25 from Subsystem  2, Output  5, Gain= 1.0                             dy-5
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                                     Yaw Actuator Model
System Output 26 from Subsystem  3, Output  1, Gain= 1.0                             dz-1
System Output 27 from Subsystem  3, Output  2, Gain= 1.0                             dz-2
System Output 28 from Subsystem  3, Output  3, Gain= 1.0                             dz-3
System Output 29 from Subsystem  3, Output  4, Gain= 1.0                             dz-4
System Output 30 from Subsystem  3, Output  5, Gain= 1.0                             dz-5
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  4                                              Vehicle to Sensors
Subsystem  1, Output  1 to Subsystem  4, Input  1, Gain= 1.0                         IMU-roll
Subsystem  1, Output  3 to Subsystem  4, Input  2, Gain= 1.0                         IMU-ptch
Subsystem  1, Output  5 to Subsystem  4, Input  3, Gain= 1.0                         IMU-yaw
Subsystem  1, Output  2 to Subsystem  4, Input  4, Gain= 1.0                         Rate-Gyro-Roll
Subsystem  1, Output  4 to Subsystem  4, Input  5, Gain= 1.0                         Rate-Gyro-Ptch
Subsystem  1, Output  6 to Subsystem  4, Input  6, Gain= 1.0                         Rate-Gyro-Yaw
Subsystem  1, Output 12 to Subsystem  4, Input  7, Gain= 1.0                         Accelerom-Yddot
Subsystem  1, Output 13 to Subsystem  4, Input  8, Gain= 1.0                         Accelerom-Zddot
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                              Pitch Actuators to Vehicle
Subsystem  2, Output  1 to Subsystem  1, Input  1, Gain= 1.0                         dy-1
Subsystem  2, Output  2 to Subsystem  1, Input  2, Gain= 1.0                         dy-2
Subsystem  2, Output  3 to Subsystem  1, Input  3, Gain= 1.0                         dy-3
Subsystem  2, Output  4 to Subsystem  1, Input  4, Gain= 1.0                         dy-4
Subsystem  2, Output  5 to Subsystem  1, Input  5, Gain= 1.0                         dy-5
Subsystem  2, Output  6 to Subsystem  1, Input  6, Gain= 1.0                         dy-ddot-1
Subsystem  2, Output  7 to Subsystem  1, Input  7, Gain= 1.0                         dy-ddot-2
Subsystem  2, Output  8 to Subsystem  1, Input  8, Gain= 1.0                         dy-ddot-3
Subsystem  2, Output  9 to Subsystem  1, Input  9, Gain= 1.0                         dy-ddot-4
Subsystem  2, Output 10 to Subsystem  1, Input 10, Gain= 1.0                         dy-ddot-5
..............................................................................
SUBSYSTEM NO  3 GOES TO SUBSYSTEM NO  1                                              Yaw Actuators to Vehicle
Subsystem  3, Output  1 to Subsystem  1, Input 11, Gain= 1.0                         dz-1
Subsystem  3, Output  2 to Subsystem  1, Input 12, Gain= 1.0                         dz-2
Subsystem  3, Output  3 to Subsystem  1, Input 13, Gain= 1.0                         dz-3
Subsystem  3, Output  4 to Subsystem  1, Input 14, Gain= 1.0                         dz-4
Subsystem  3, Output  5 to Subsystem  1, Input 15, Gain= 1.0                         dz-5
Subsystem  3, Output  6 to Subsystem  1, Input 16, Gain= 1.0                         dz-ddot-1
Subsystem  3, Output  7 to Subsystem  1, Input 17, Gain= 1.0                         dz-ddot-2
Subsystem  3, Output  8 to Subsystem  1, Input 18, Gain= 1.0                         dz-ddot-3
Subsystem  3, Output  9 to Subsystem  1, Input 19, Gain= 1.0                         dz-ddot-4
Subsystem  3, Output 10 to Subsystem  1, Input 20, Gain= 1.0                         dz-ddot-5
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                              Pitch Load-Torque Feedback
Subsystem  1, Output 14 to Subsystem  2, Input  6, Gain= 1.0                         TLY-1
Subsystem  1, Output 15 to Subsystem  2, Input  7, Gain= 1.0                         TLY-2
Subsystem  1, Output 16 to Subsystem  2, Input  8, Gain= 1.0                         TLY-3
Subsystem  1, Output 17 to Subsystem  2, Input  9, Gain= 1.0                         TLY-4
Subsystem  1, Output 18 to Subsystem  2, Input 10, Gain= 1.0                         TLY-5
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  3                                              Yaw Load-Torque Feedback
Subsystem  1, Output 19 to Subsystem  3, Input  6, Gain= 1.0                         TLZ-1
Subsystem  1, Output 20 to Subsystem  3, Input  7, Gain= 1.0                         TLZ-2
Subsystem  1, Output 21 to Subsystem  3, Input  8, Gain= 1.0                         TLZ-3
Subsystem  1, Output 22 to Subsystem  3, Input  9, Gain= 1.0                         TLZ-4
Subsystem  1, Output 23 to Subsystem  3, Input 10, Gain= 1.0                         TLZ-5
..............................................................................
Definitions of Inputs  =  11
Engine# 1 Ptch Deflect Command dy-1 (rad)  
Engine# 2 Ptch Deflect Command dy-2 (rad)  
Engine# 3 Ptch Deflect Command dy-3 (rad)  
Engine# 4 Ptch Deflect Command dy-4 (rad)  
Engine# 5 Ptch Deflect Command dy-5 (rad)  
Engine# 1 Yaw  Deflect Command dz-1 (rad)  
Engine# 2 Yaw  Deflect Command dz-2 (rad)  
Engine# 3 Yaw  Deflect Command dz-3 (rad)  
Engine# 4 Yaw  Deflect Command dz-4 (rad)  
Engine# 5 Yaw  Deflect Command dz-5 (rad)  
Wind Gust Velocity (ft/sec)                                                              
 
Definitions of Outputs =  30
Roll Attitude  (phi-body) (radians)   
Pitch Attitude (thet-bdy) (radians)     
Yaw  Attitude  (psi-body) (radians)    
Roll Rate Gyro  (p-flex)  (rad/sec)                   
Pitch Rate Gyro (q-flex)  (rad/sec)                    
Yaw  Rate Gyro  (r-flex)  (rad/sec)                                                                                                                                          
Accelerom #  1, Y-ddot Accelerat. (ft/sec^2)  
Accelerom #  2, Z-ddot Accelerat. (ft/sec^2)  
Angle of attack, alfa, (radians)                                                                                                                                             
Angle of sideslip, beta, (radian)                                                                                                                                            
Load-Torque Pitch TLY-Eng-1
Load-Torque Pitch TLY-Eng-2
Load-Torque Pitch TLY-Eng-3
Load-Torque Pitch TLY-Eng-4
Load-Torque Pitch TLY-Eng-5
Load-Torque Yaw   TLZ-Eng-1
Load-Torque Yaw   TLZ-Eng-2
Load-Torque Yaw   TLZ-Eng-3
Load-Torque Yaw   TLZ-Eng-4
Load-Torque Yaw   TLZ-Eng-5
Engine # 1 Pitch Deflection dy-1 (rad)
Engine # 2 Pitch Deflection dy-2 (rad)
Engine # 3 Pitch Deflection dy-3 (rad)
Engine # 4 Pitch Deflection dy-4 (rad)
Engine # 5 Pitch Deflection dy-5 (rad)
Engine # 1 Yaw   Deflection dz-1 (rad)
Engine # 2 Yaw   Deflection dz-2 (rad)
Engine # 3 Yaw   Deflection dz-3 (rad)
Engine # 4 Yaw   Deflection dz-4 (rad)
Engine # 5 Yaw   Deflection dz-5 (rad)
---------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Shuttle Stage-1 TVC Matrix at Max-Q                                                                                    
Matrix TVC
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Shuttle Ascent, Max_Q, Pitch Hinf Design Model
System
pitch_des
---------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Shuttle Ascent, Max_Q, Pitch Analysis with Slosh & TVC
System
pitch_anal
---------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Shuttle Plant Model at Max-Q (Flex Vehicle, Actuators, Sensors)
System
plant
----------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
