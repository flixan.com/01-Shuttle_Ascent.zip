BATCH MODE INSTRUCTIONS ...............                                                             
Batch for preparing the Shuttle Ascent, First Stage Max-Q, Longitudinal Axis Models
! This batch set creates Space Shuttle Ascent models at Max Dynamic Pressure which occurs
! 55 seconds after lift-off. First, a rigid-body model, and second a flexible vehicle model
! with 18 symmetric (longitudinal) bending modes. External fuel tank slosh dynamics are also 
! included in the flex model and the tail-wags-dog option is turned on. The flex model is 
! modified to retain only the longitudinal dynamics, inputs, and outputs. The SSME and the 
! SRB hydraulic actuator models are also created. The pitch flight control system is 
! contructed in the z-domain at 40 msec sampling period. The flex vehicle, actuators, and TVC 
! gains are combined together to create a continuous plant model and discretized at 40 msec.
! The discrete plant and flight controller are combined together in two configurations, an
! open-loop for stability analysis, and a closed-loop for simulations. The derived systems are 
! converted to Matlab format.
!
Flight Vehicle   : Shuttle Ascent, Max_Q, T=55 sec (Rigid Body)                
Flight Vehicle   : Shuttle Ascent, Max_Q, T=55 sec, Flex Vehicle with Slosh and TWD          
System Modificat : Shuttle Ascent, Max_Q, T=55 sec, Flex Pitch Vehicle with Slosh and TWD
Actuator Model   : Shuttle Main Engine Actuator
Actuator Model   : Solid Rocket Booster Actuator    
Transf-Function  : Pitch Axis Discrete FCS 
System Connection: Pitch Plant (Flex Vehicle, Actuators, TVC, TWD)  
S-Z-Transform    : Discrete Pitch Plant (Flex Vehicle, Actuators, TVC, TWD)
System Connection: Open-Loop Pitch (Plant Model + Controller)  
System Connection: Closed Loop (Plant Model + Controller)  
To Matlab Format : Shuttle Ascent, Max_Q, T=55 sec, Flex Pitch Vehicle with Slosh and TWD
To Matlab Format : Shuttle Main Engine Actuator
To Matlab Format : Solid Rocket Booster Actuator
To Matlab Format : Pitch Axis Discrete FCS
To Matlab Format : Pitch Plant (Flex Vehicle, Actuators, TVC, TWD)
To Matlab Format : Discrete Pitch Plant (Flex Vehicle, Actuators, TVC, TWD)
To Matlab Format : Open-Loop Pitch (Plant Model + Controller)
To Matlab Format : Closed Loop (Plant Model + Controller)
---------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Shuttle Ascent, Max_Q, T=55 sec (Rigid Body)
! Rigid Body Shuttle Model during First Stage at Max Dynamic pressure. 
! Slosh, Bending, and Tail-Wag-Dog is Not Included.
Body Axes Output, Attitude=Rate Integral,Without GAFD, No Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Planet Radius (Re) (ft)   :   0.1093E+6    32.174       0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   0.27E+8      0.22E+9      0.234E+9     0.5e5,  0.9e7, 0.3e5    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   83.98        0.0         -2.18
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   1.4          1400.0       600.0        37000.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   52.0         49.66        0.0000       4.0    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  -4.1         -0.15         0.0          0.0    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0000       65.7         0.0000       0.0000       0.0000       0.0000    
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:   Gust         00.0         90.0    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   2690.0       15.0         15.0  
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   83.98        0.0         -2.18        -9.482e-10
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.0         -0.00046      0.0          0.0          0.0          0.0000      -0.00054    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0         -0.027        0.0000       0.0012       0.0000       0.0000       0.0000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:   0.0         -0.035        0.0000      -0.0047       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.0         -0.028        0.0000       0.0000       0.0000      -0.0007
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:   0.0         -0.01         0.0000      -0.004        0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0          0.0247       0.0000       0.0000       0.0000       0.0015    

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  0   NO TWD  

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  5   NO TWD

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Middle SSME      Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  275000.0     275000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -16.0         0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0        4032.0        3.0   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  19.0         0.0          -32.0    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : Left SSME        Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  275000.0     275000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -10.0         0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0        4032.0        3.0   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  17.0        -4.5          -23.0    
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : Right SSME       Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  275000.0     275000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -10.0         0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0        4032.0        3.0   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  17.0         4.5          -23.0    
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : Left SRB         Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.23e+7      0.23e+7
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0          0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  540.0        0.12e+5      -0.7   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  0.0         -21.0          0.0    
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : Left SRB         Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.23e+7      0.23e+7
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0          0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  540.0        0.12e+5      -0.7   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  0.0         +21.0          0.0    

Number of Gyros, (Attitude and Rate)                                                     :  0

Number of Accelerometers, Along Axis: (x,y,z)                                            :  0

Number of Vane Sensors, (Measuring Alpha or Beta)                                        :  0

Number of Slosh Modes                                                                    :  0

Number of Bending Modes                                                                  :  0
                                                                                                    
---------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Shuttle Ascent, Max_Q, T=55 sec, Flex Vehicle with Slosh and TWD
! Flexible Shuttle vehicle model during First Stage at Max Dynamic pressure. 
! Slosh due to LOX and LH2 fuel tanks, and Tail-Wag-Dog is Included.
! Only 18 Pitch structural modes were selected
Body Axes Output, Attitude=Rate Integral,Without GAFD, No Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Planet Radius (Re) (ft)   :   0.1093E+6    32.174       0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   0.27E+8      0.22E+9      0.234E+9     0.5e5,  0.9e7, 0.3e5    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   83.98        0.0         -2.18
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   1.4          1400.0       600.0        37000.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   52.0         49.66        0.0000       4.0    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  -4.1         -0.15         0.0          0.0    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0000       65.7         0.0000       0.0000       0.0000       0.0000    
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:   Gust         00.0         90.0    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   2690.0       15.0         15.0  
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   83.98        0.0         -2.18        -9.482e-10
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.0         -0.00046      0.0          0.0          0.0          0.0000      -0.00054    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0         -0.027        0.0000       0.0012       0.0000       0.0000       0.0000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:   0.0         -0.035        0.0000      -0.0047       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.0         -0.028        0.0000       0.0000       0.0000      -0.0007
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:   0.0         -0.01         0.0000      -0.004        0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0          0.0247       0.0000       0.0000       0.0000       0.0015    

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  0   NO TWD  

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  5   WITH TWD

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Middle SSME      Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  275000.0     275000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -16.0         0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0        4032.0        3.0   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  19.0         0.0          -32.0    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : Left SSME        Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  275000.0     275000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -10.0         0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0        4032.0        3.0   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  17.0        -4.5          -23.0    
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : Right SSME       Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  275000.0     275000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -10.0         0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0        4032.0        3.0   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  17.0         4.5          -23.0    
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : Left SRB         Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.23e+7      0.23e+7
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0          0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  540.0        0.12e+5      -0.7   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  0.0         -21.0          0.0    
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : Left SRB         Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.23e+7      0.23e+7
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0          0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  540.0        0.12e+5      -0.7   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  0.0         +21.0          0.0    

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Roll   Rate            108.3      0.00      -28.00    
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Pitch  Rate            108.3      0.00      -28.00    
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Yaw    Rate            108.3      0.00      -28.00    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  2
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.      108.3      0.00      -28.00    
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.      108.3      0.00      -28.00    

Number of Vane Sensors, (Measuring Alpha or Beta)                                        :  0

Number of Slosh Modes                                                                    :  2
LOX Slosh Mass (slug), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft) :  3064.0   2.428  2.428  0.0015  0.0015  143.00   0.0    0.0    
LH2 Slosh Mass (slug), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft) :  512.0    2.058  2.058  0.0018  0.0018   87.00   0.0    0.0   

Number of Bending Modes                                                                  : 18
Shuttle Ascent, Max_Q, T=55 sec, Rigid Body with Slosh/TWD, Pitch Modes                             
---------------------------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR THE PITCH MODES         
Shuttle Ascent, Max_Q, T=55 sec, Rigid Body with Slosh/TWD, Pitch Modes                             
! Pitch Modes selected between the five engine gimbals and the pitch gyro and accelerometer sensors                 

MODE # 1/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    12.151       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.61387D+00  -0.61734D-01  -0.15612D+01   0.42653D-02  -0.13384D-01   0.11436D-02
Shuttle Main Engine  # 2 (left    2254     0.50962D+00  -0.91117D-01  -0.15971D+01   0.29002D-02  -0.13111D-01  -0.75217D-03
Shuttle Main Engine  # 3 (righ    2091     0.50867D+00  -0.92870D-01  -0.15757D+01   0.44489D-02  -0.23288D-01   0.15293D-02
Solid Rocket Booster # 4 (left    1367    -0.44066D-01   0.13004D+00  -0.78224D+00  -0.17006D+00  -0.25292D-01  -0.64782D-03
Solid Rocket Booster # 5 (righ     367    -0.31986D-01  -0.13981D+00  -0.78234D+00   0.17183D+00  -0.25481D-01   0.11537D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372    -0.18730D-01   0.10486D+01   0.88193D+00   0.19468D+00  -0.99742D-03   0.14856D-02
Booster Gyro (right)               372    -0.18730D-01   0.10486D+01   0.88193D+00   0.19468D+00  -0.99742D-03   0.14856D-02
Booster Gyro (right)               372    -0.18730D-01   0.10486D+01   0.88193D+00   0.19468D+00  -0.99742D-03   0.14856D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.39853D-01  -0.23900D+00
IMU/ Accelerometer (right)        2322     0.00000D+00   0.39853D-01  -0.23900D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.83451D-02  -0.68063D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00   0.93311D-02  -0.37481D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.83451D-02  -0.68063D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE # 2/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    15.140       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.21481D+01  -0.12488D-01  -0.12885D+01  -0.76709D-03  -0.10757D+00   0.23267D-03
Shuttle Main Engine  # 2 (left    2254     0.12522D+01   0.63631D-02  -0.14857D+01  -0.15500D-02  -0.10868D+00  -0.31345D-02
Shuttle Main Engine  # 3 (righ    2091     0.12599D+01   0.42062D-03  -0.15161D+01  -0.24712D-03  -0.12589D+00   0.23136D-02
Solid Rocket Booster # 4 (left    1367    -0.71271D-01  -0.19005D+00  -0.60001D+00   0.31932D-01  -0.12724D-01   0.24388D-02
Solid Rocket Booster # 5 (righ     367    -0.70664D-01   0.18430D+00  -0.61031D+00  -0.30578D-01  -0.12991D-01  -0.22746D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372    -0.59885D-01  -0.13794D+00   0.29224D+00  -0.26555D-01   0.36988D-05  -0.10557D-02
Booster Gyro (right)               372    -0.59885D-01  -0.13794D+00   0.29224D+00  -0.26555D-01   0.36988D-05  -0.10557D-02
Booster Gyro (right)               372    -0.59885D-01  -0.13794D+00   0.29224D+00  -0.26555D-01   0.36988D-05  -0.10557D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.40880D-01   0.13408D+01
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.40880D-01   0.13408D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.39555D-03  -0.70534D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.70712D-03   0.84404D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.39555D-03  -0.70534D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE # 3/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    15.693       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088    -0.12992D+01  -0.66250D-02   0.60877D+00   0.28522D-03   0.56108D-01   0.68663D-04
Shuttle Main Engine  # 2 (left    2254    -0.82874D+00  -0.16774D-01   0.71381D+00   0.48283D-03   0.57134D-01   0.21515D-02
Shuttle Main Engine  # 3 (righ    2091    -0.83395D+00  -0.12642D-01   0.72895D+00   0.38161D-05   0.66695D-01  -0.14364D-02
Solid Rocket Booster # 4 (left    1367     0.68673D-01   0.17918D+00   0.46836D+00  -0.32081D-01   0.10253D-01  -0.25210D-02
Solid Rocket Booster # 5 (righ     367     0.68352D-01  -0.17160D+00   0.42289D+00   0.30661D-01   0.92213D-02   0.23298D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.62085D-01   0.15116D+00  -0.20092D+00   0.28375D-01  -0.68186D-03   0.69469D-03
Booster Gyro (right)               372     0.62085D-01   0.15116D+00  -0.20092D+00   0.28375D-01  -0.68186D-03   0.69469D-03
Booster Gyro (right)               372     0.62085D-01   0.15116D+00  -0.20092D+00   0.28375D-01  -0.68186D-03   0.69469D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.40106D-01  -0.89821D+00
IMU/ Accelerometer (right)        2322     0.00000D+00   0.40106D-01  -0.89821D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00   0.57850D-04   0.50328D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00   0.10319D-02  -0.68601D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00   0.57850D-04   0.50328D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE # 4/ 13, Frequency (rad/sec), Damping (zeta), Generalized Mass=    16.090       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.79857D+00  -0.15479D-02  -0.66802D+00  -0.55618D-02  -0.26927D-01  -0.87260D-03
Shuttle Main Engine  # 2 (left    2254     0.56772D+00   0.54210D-01  -0.69196D+00  -0.61384D-02  -0.27682D-01  -0.29850D-02
Shuttle Main Engine  # 3 (righ    2091     0.58298D+00   0.51071D-01  -0.75369D+00  -0.51469D-02  -0.37168D-01   0.32990D-04
Solid Rocket Booster # 4 (left    1367    -0.21954D+00   0.33113D+00   0.39007D+00   0.45670D-02   0.94889D-02   0.19432D-01
Solid Rocket Booster # 5 (righ     367    -0.21882D+00  -0.35914D+00   0.39940D+00  -0.79291D-03   0.96940D-02  -0.18802D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372    -0.17451D+00  -0.58460D+00  -0.19526D+00   0.14174D-02  -0.19996D-01   0.34300D-01
Booster Gyro (right)               372    -0.17451D+00  -0.58460D+00  -0.19526D+00   0.14174D-02  -0.19996D-01   0.34300D-01
Booster Gyro (right)               372    -0.17451D+00  -0.58460D+00  -0.19526D+00   0.14174D-02  -0.19996D-01   0.34300D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.14423D+00   0.14354D-01
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.14423D+00   0.14354D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.13477D-02   0.15323D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.24757D-02  -0.12438D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.13477D-02   0.15323D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE # 5/ 15, Frequency (rad/sec), Damping (zeta), Generalized Mass=    18.177       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.95973D+00   0.83257D-02  -0.16053D+01   0.26111D-02  -0.64025D-01   0.75128D-03
Shuttle Main Engine  # 2 (left    2254     0.45384D+00   0.25019D-03  -0.17131D+01  -0.50723D-03  -0.61160D-01  -0.23294D-02
Shuttle Main Engine  # 3 (righ    2091     0.45965D+00  -0.31172D-02  -0.17332D+01   0.26284D-02  -0.87218D-01   0.21815D-02
Solid Rocket Booster # 4 (left    1367     0.56472D-01   0.16644D+01   0.11862D+01  -0.99252D-01   0.31171D-01  -0.41490D-01
Solid Rocket Booster # 5 (righ     367     0.57456D-01  -0.16596D+01   0.11897D+01   0.97726D-01   0.31244D-01   0.41359D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.10708D+00   0.83581D+00  -0.36541D+00   0.80592D-01   0.13846D-02  -0.10854D-01
Booster Gyro (right)               372     0.10708D+00   0.83581D+00  -0.36541D+00   0.80592D-01   0.13846D-02  -0.10854D-01
Booster Gyro (right)               372     0.10708D+00   0.83581D+00  -0.36541D+00   0.80592D-01   0.13846D-02  -0.10854D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.42075D-01  -0.79261D+00
IMU/ Accelerometer (right)        2322     0.00000D+00   0.42075D-01  -0.79261D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00   0.26556D-04   0.83193D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00   0.18277D-02  -0.11793D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00   0.26556D-04   0.83193D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE # 6/ 16, Frequency (rad/sec), Damping (zeta), Generalized Mass=    18.848       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088    -0.23209D+00  -0.10458D+00  -0.20549D+00   0.36372D-02  -0.83291D-02   0.73218D-03
Shuttle Main Engine  # 2 (left    2254    -0.28635D+00  -0.13484D+00  -0.22837D+00   0.27263D-02  -0.61628D-02   0.10002D-02
Shuttle Main Engine  # 3 (righ    2091    -0.29097D+00  -0.13344D+00  -0.20182D+00   0.35764D-02  -0.78791D-02   0.43192D-03
Solid Rocket Booster # 4 (left    1367    -0.64847D-01  -0.25838D+01   0.47520D+00  -0.82202D-01   0.13514D-01   0.57914D-01
Solid Rocket Booster # 5 (righ     367    -0.60218D-01   0.26230D+01   0.49309D+00   0.88382D-01   0.13951D-01  -0.58750D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372    -0.22064D-01   0.14864D+00  -0.20905D+00   0.93496D-01  -0.21366D-01   0.82717D-02
Booster Gyro (right)               372    -0.22064D-01   0.14864D+00  -0.20905D+00   0.93496D-01  -0.21366D-01   0.82717D-02
Booster Gyro (right)               372    -0.22064D-01   0.14864D+00  -0.20905D+00   0.93496D-01  -0.21366D-01   0.82717D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.29359D-01  -0.88389D+00
IMU/ Accelerometer (right)        2322     0.00000D+00   0.29359D-01  -0.88389D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00   0.17907D-02   0.57875D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00   0.60063D-02  -0.93699D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00   0.17907D-02   0.57875D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE # 7/ 18, Frequency (rad/sec), Damping (zeta), Generalized Mass=    20.482       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.25368D+01  -0.11585D+00  -0.14977D+01   0.69168D-02  -0.81840D-01   0.58064D-03
Shuttle Main Engine  # 2 (left    2254     0.18525D+01  -0.15037D+00  -0.16759D+01   0.49554D-02  -0.86411D-01  -0.57557D-02
Shuttle Main Engine  # 3 (righ    2091     0.18564D+01  -0.16566D+00  -0.16770D+01   0.82380D-02  -0.13214D+00   0.75901D-02
Solid Rocket Booster # 4 (left    1367    -0.74671D-01  -0.70391D+00   0.13045D+01  -0.11705D-01   0.35881D-01   0.13422D-01
Solid Rocket Booster # 5 (righ     367    -0.10621D+00   0.72125D+00   0.13050D+01   0.19030D-01   0.35971D-01  -0.13313D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.29715D-02   0.27715D-01   0.27767D-02   0.61756D-04  -0.18222D-01  -0.53990D-03
Booster Gyro (right)               372     0.29715D-02   0.27715D-01   0.27767D-02   0.61756D-04  -0.18222D-01  -0.53990D-03
Booster Gyro (right)               372     0.29715D-02   0.27715D-01   0.27767D-02   0.61756D-04  -0.18222D-01  -0.53990D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.45454D-01   0.10076D+01
IMU/ Accelerometer (right)        2322     0.00000D+00   0.45454D-01   0.10076D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.38883D-02   0.53817D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.23400D-01   0.58087D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.38883D-02   0.53817D-01   0.00000D+00   0.00000D+00   0.00000D+00

MODE # 8/ 24, Frequency (rad/sec), Damping (zeta), Generalized Mass=    26.807       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088    -0.99888D+00   0.11457D-01   0.91668D+00   0.85622D-03   0.72881D-01  -0.37075D-02
Shuttle Main Engine  # 2 (left    2254    -0.44477D+00  -0.16681D-01   0.10202D+01   0.30538D-02   0.70027D-01   0.34051D-02
Shuttle Main Engine  # 3 (righ    2091    -0.45885D+00  -0.10098D-01   0.10915D+01  -0.15010D-02   0.12151D+00  -0.33239D-02
Solid Rocket Booster # 4 (left    1367     0.10451D+00   0.79056D-01   0.12859D+01  -0.52508D-01   0.51340D-01  -0.60871D-03
Solid Rocket Booster # 5 (righ     367     0.11974D+00  -0.12120D+00   0.12673D+01   0.55402D-01   0.50886D-01   0.22632D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.43116D+00   0.28726D+00   0.14082D+01   0.67135D-01  -0.66860D-01  -0.13148D-02
Booster Gyro (right)               372     0.43116D+00   0.28726D+00   0.14082D+01   0.67135D-01  -0.66860D-01  -0.13148D-02
Booster Gyro (right)               372     0.43116D+00   0.28726D+00   0.14082D+01   0.67135D-01  -0.66860D-01  -0.13148D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.62216D-02   0.13837D+01
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.62216D-02   0.13837D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00   0.16830D-01  -0.79862D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.41382D-01   0.15414D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00   0.16830D-01  -0.79862D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE # 9/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    30.578       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088    -0.52758D+00   0.16853D-01  -0.17895D+01   0.77546D-02  -0.12108D+00   0.56806D-02
Shuttle Main Engine  # 2 (left    2254    -0.12477D+01  -0.44575D-01  -0.18828D+01  -0.60190D-02  -0.84612D-01   0.86822D-02
Shuttle Main Engine  # 3 (righ    2091    -0.12400D+01  -0.20271D-01  -0.19839D+01   0.78156D-02  -0.18823D+00  -0.48268D-02
Solid Rocket Booster # 4 (left    1367     0.40786D+00  -0.10965D+00   0.88107D-01  -0.48684D-03   0.37700D-02   0.55896D-02
Solid Rocket Booster # 5 (righ     367     0.40720D+00   0.12555D+00   0.26046D-01   0.47304D-02   0.15391D-02  -0.61044D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.30031D+00  -0.70696D-01   0.39910D-01   0.17851D-01  -0.18756D-01  -0.71738D-02
Booster Gyro (right)               372     0.30031D+00  -0.70696D-01   0.39910D-01   0.17851D-01  -0.18756D-01  -0.71738D-02
Booster Gyro (right)               372     0.30031D+00  -0.70696D-01   0.39910D-01   0.17851D-01  -0.18756D-01  -0.71738D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.72530D-01   0.12839D+01
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.72530D-01   0.12839D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.29102D-02  -0.87080D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.48249D-03  -0.25094D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.29102D-02  -0.87080D-01   0.00000D+00   0.00000D+00   0.00000D+00

MODE #10/ 32, Frequency (rad/sec), Damping (zeta), Generalized Mass=    33.964       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088    -0.32020D+00   0.88663D+00   0.14321D+01  -0.81928D-04  -0.21959D-02   0.11306D-01
Shuttle Main Engine  # 2 (left    2254    -0.35739D+00   0.74564D+00   0.13241D+01   0.13601D-01  -0.12473D-01   0.28843D-01
Shuttle Main Engine  # 3 (righ    2091    -0.58300D+00   0.76525D+00   0.15168D+01  -0.12006D-01   0.13084D+00   0.52949D-02
Solid Rocket Booster # 4 (left    1367     0.26421D-01  -0.36238D-01   0.34847D+00   0.15886D-01   0.16057D-01   0.12283D-02
Solid Rocket Booster # 5 (righ     367    -0.13820D-01  -0.31545D+00  -0.18045D+00   0.35974D-01  -0.30624D-03   0.10033D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.88235D-01   0.29200D+00   0.48868D+00   0.68083D-01  -0.20404D-01   0.63030D-03
Booster Gyro (right)               372     0.88235D-01   0.29200D+00   0.48868D+00   0.68083D-01  -0.20404D-01   0.63030D-03
Booster Gyro (right)               372     0.88235D-01   0.29200D+00   0.48868D+00   0.68083D-01  -0.20404D-01   0.63030D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.16782D+00   0.15503D+01
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.16782D+00   0.15503D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.25371D-01   0.27711D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00   0.12726D+00   0.67246D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.25371D-01   0.27711D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE #11/ 34, Frequency (rad/sec), Damping (zeta), Generalized Mass=    35.498       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088    -0.30318D+00  -0.16937D+01   0.99652D+00  -0.98255D-02  -0.33476D-01  -0.15841D-01
Shuttle Main Engine  # 2 (left    2254    -0.91313D+00  -0.14398D+01   0.89323D+00  -0.11874D-01  -0.53227D-01  -0.28643D-01
Shuttle Main Engine  # 3 (righ    2091    -0.70942D+00  -0.14601D+01   0.94854D+00   0.58398D-02   0.43190D-01  -0.39227D-02
Solid Rocket Booster # 4 (left    1367    -0.10646D+00   0.63815D+00  -0.78736D+00  -0.76268D-01  -0.24536D-01  -0.22195D-01
Solid Rocket Booster # 5 (righ     367    -0.44027D-02   0.13292D+00  -0.10964D+00   0.12440D-01  -0.41581D-02  -0.41291D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372    -0.86481D-02   0.80565D-01  -0.96315D-01   0.11181D-01   0.23394D-02  -0.11250D-02
Booster Gyro (right)               372    -0.86481D-02   0.80565D-01  -0.96315D-01   0.11181D-01   0.23394D-02  -0.11250D-02
Booster Gyro (right)               372    -0.86481D-02   0.80565D-01  -0.96315D-01   0.11181D-01   0.23394D-02  -0.11250D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.31000D+00   0.79286D+00
IMU/ Accelerometer (right)        2322     0.00000D+00   0.31000D+00   0.79286D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00   0.69531D-01  -0.48298D-02   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.41072D+00  -0.62013D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00   0.69531D-01  -0.48298D-02   0.00000D+00   0.00000D+00   0.00000D+00

MODE #12/ 35, Frequency (rad/sec), Damping (zeta), Generalized Mass=    36.295       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.40459D+00  -0.14763D+00   0.54950D+00  -0.15817D-02   0.27566D-01  -0.85426D-02
Shuttle Main Engine  # 2 (left    2254     0.41402D+00  -0.10928D+00   0.51682D+00   0.26864D-02   0.61432D-02  -0.12754D-01
Shuttle Main Engine  # 3 (righ    2091     0.42872D+00  -0.13219D+00   0.60226D+00  -0.21461D-02   0.82596D-01   0.62428D-02
Solid Rocket Booster # 4 (left    1367     0.10992D+00   0.11266D-02  -0.24599D+00  -0.18260D-01  -0.10123D-01   0.44728D-03
Solid Rocket Booster # 5 (righ     367     0.14737D+00   0.18994D+00  -0.16801D+00   0.11291D-01  -0.76034D-02  -0.78228D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.64994D-01   0.57413D-01  -0.27385D+00   0.17020D-02  -0.56645D-04  -0.33797D-02
Booster Gyro (right)               372     0.64994D-01   0.57413D-01  -0.27385D+00   0.17020D-02  -0.56645D-04  -0.33797D-02
Booster Gyro (right)               372     0.64994D-01   0.57413D-01  -0.27385D+00   0.17020D-02  -0.56645D-04  -0.33797D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.24803D-01  -0.11839D+01
IMU/ Accelerometer (right)        2322     0.00000D+00   0.24803D-01  -0.11839D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00   0.24553D-01   0.12583D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.13430D+00   0.36349D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00   0.24553D-01   0.12583D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE #13/ 37, Frequency (rad/sec), Damping (zeta), Generalized Mass=    37.442       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.76582D+00  -0.14631D+00  -0.22464D+01   0.42452D-02  -0.62740D-02   0.11339D-01
Shuttle Main Engine  # 2 (left    2254     0.96496D+00  -0.81035D-01  -0.20776D+01  -0.13459D-01   0.21472D-01  -0.24127D-01
Shuttle Main Engine  # 3 (righ    2091     0.10320D+01  -0.12248D+00  -0.23549D+01   0.15532D-01  -0.21271D+00   0.22418D-01
Solid Rocket Booster # 4 (left    1367    -0.47666D-02  -0.10956D+00   0.42215D+00   0.36658D-01   0.17263D-01   0.44713D-02
Solid Rocket Booster # 5 (righ     367    -0.21894D-01   0.58799D-01   0.44840D+00  -0.38696D-01   0.18023D-01  -0.20471D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372    -0.22677D-02  -0.15509D+00   0.37667D+00  -0.27134D-01   0.27468D-02   0.60250D-04
Booster Gyro (right)               372    -0.22677D-02  -0.15509D+00   0.37667D+00  -0.27134D-01   0.27468D-02   0.60250D-04
Booster Gyro (right)               372    -0.22677D-02  -0.15509D+00   0.37667D+00  -0.27134D-01   0.27468D-02   0.60250D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.32877D-01  -0.17050D+01
IMU/ Accelerometer (right)        2322     0.00000D+00   0.32877D-01  -0.17050D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.12436D-01  -0.14564D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00   0.60787D-01   0.56718D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.12436D-01  -0.14564D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE #14/ 42, Frequency (rad/sec), Damping (zeta), Generalized Mass=    45.687       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088    -0.69721D+00   0.86952D-02  -0.29544D+00   0.10504D-01  -0.17825D-01   0.87456D-02
Shuttle Main Engine  # 2 (left    2254    -0.53236D+00  -0.11396D+00  -0.22356D+00   0.24083D-02   0.23287D-01   0.15601D-01
Shuttle Main Engine  # 3 (righ    2091    -0.56539D+00  -0.87458D-01  -0.25947D+00   0.13151D-01  -0.69950D-01  -0.28992D-02
Solid Rocket Booster # 4 (left    1367     0.18956D-01  -0.22788D-01  -0.92049D+00  -0.47189D-01  -0.45652D-01   0.91966D-03
Solid Rocket Booster # 5 (righ     367     0.20266D-01   0.96937D-02  -0.90802D+00   0.46610D-01  -0.45012D-01  -0.35027D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.25123D+00   0.11286D+00   0.54824D+00   0.17645D-01  -0.50568D-01   0.94544D-03
Booster Gyro (right)               372     0.25123D+00   0.11286D+00   0.54824D+00   0.17645D-01  -0.50568D-01   0.94544D-03
Booster Gyro (right)               372     0.25123D+00   0.11286D+00   0.54824D+00   0.17645D-01  -0.50568D-01   0.94544D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.11279D+00   0.51278D+00
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.11279D+00   0.51278D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.64813D-02  -0.23399D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.38795D-02   0.87490D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.64813D-02  -0.23399D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE #15/ 50, Frequency (rad/sec), Damping (zeta), Generalized Mass=    48.610       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.44332D+00  -0.76243D-01   0.12966D+01  -0.11190D-01  -0.35530D-01   0.77468D-02
Shuttle Main Engine  # 2 (left    2254    -0.12217D-01   0.18331D-01   0.11017D+01   0.14168D-01  -0.60520D-01  -0.96941D-03
Shuttle Main Engine  # 3 (righ    2091     0.57323D-01   0.14347D-01   0.12055D+01   0.33612D-02  -0.39469D-02  -0.11347D-01
Solid Rocket Booster # 4 (left    1367    -0.25431D-01   0.39886D+00  -0.18013D+00   0.70672D-03  -0.59874D-02  -0.17633D-01
Solid Rocket Booster # 5 (righ     367     0.16305D-01  -0.43785D-01  -0.49823D+00  -0.24883D-02  -0.23245D-01   0.23070D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.69723D-01   0.33177D+00   0.42159D+00   0.53650D-01  -0.12662D-01   0.18620D-02
Booster Gyro (right)               372     0.69723D-01   0.33177D+00   0.42159D+00   0.53650D-01  -0.12662D-01   0.18620D-02
Booster Gyro (right)               372     0.69723D-01   0.33177D+00   0.42159D+00   0.53650D-01  -0.12662D-01   0.18620D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.33148D+00  -0.17647D+01
IMU/ Accelerometer (right)        2322     0.00000D+00   0.33148D+00  -0.17647D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.36111D+00   0.20845D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.10939D+01   0.38758D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.36111D+00   0.20845D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE #16/ 70, Frequency (rad/sec), Damping (zeta), Generalized Mass=    56.971       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.31294D-01  -0.40544D-01   0.17039D+01  -0.11862D-01   0.13120D-01  -0.32723D-01
Shuttle Main Engine  # 2 (left    2254    -0.19841D+00  -0.85045D-02   0.15871D+01   0.32801D-02  -0.16891D-02   0.53982D-03
Shuttle Main Engine  # 3 (righ    2091    -0.20535D+00  -0.25859D-01   0.16324D+01   0.14726D-02   0.61547D-01   0.37492D-02
Solid Rocket Booster # 4 (left    1367    -0.97747D-02   0.34022D-01  -0.50545D-01  -0.81761D-02  -0.23161D-02  -0.11594D-02
Solid Rocket Booster # 5 (righ     367    -0.17035D-01  -0.38862D-01  -0.50466D-01  -0.74686D-02  -0.22067D-02   0.13225D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.18147D+00   0.27699D+00   0.92335D+00   0.46290D-01  -0.29789D-01   0.27168D-02
Booster Gyro (right)               372     0.18147D+00   0.27699D+00   0.92335D+00   0.46290D-01  -0.29789D-01   0.27168D-02
Booster Gyro (right)               372     0.18147D+00   0.27699D+00   0.92335D+00   0.46290D-01  -0.29789D-01   0.27168D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.26744D+01  -0.40045D+01
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.26744D+01  -0.40045D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00   0.29302D-02  -0.71270D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00   0.12772D+00  -0.37648D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00   0.29302D-02  -0.71270D-01   0.00000D+00   0.00000D+00   0.00000D+00

MODE #17/ 71, Frequency (rad/sec), Damping (zeta), Generalized Mass=    57.153       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.20110D+00  -0.30830D-01  -0.13774D+01  -0.95080D-02  -0.97721D-02  -0.32477D-01
Shuttle Main Engine  # 2 (left    2254     0.19430D+00   0.24118D+00  -0.11543D+01  -0.39148D-01   0.18904D-02  -0.30073D-01
Shuttle Main Engine  # 3 (righ    2091     0.37011D+00   0.22290D+00  -0.15038D+01  -0.13109D-01  -0.93412D-01  -0.43994D-03
Solid Rocket Booster # 4 (left    1367     0.11680D-01  -0.49585D-01   0.46986D-01  -0.11034D-01   0.22103D-02   0.20286D-02
Solid Rocket Booster # 5 (righ     367     0.17574D-03   0.86657D-02   0.37627D-01  -0.80747D-02   0.18416D-02  -0.24379D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.53529D-01  -0.12301D+00   0.30140D+00  -0.14990D-01  -0.88176D-02   0.35194D-03
Booster Gyro (right)               372     0.53529D-01  -0.12301D+00   0.30140D+00  -0.14990D-01  -0.88176D-02   0.35194D-03
Booster Gyro (right)               372     0.53529D-01  -0.12301D+00   0.30140D+00  -0.14990D-01  -0.88176D-02   0.35194D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.43917D+01   0.36731D+01
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.43917D+01   0.36731D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.36018D-02   0.27431D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00   0.92691D-01   0.40645D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.36018D-02   0.27431D-01   0.00000D+00   0.00000D+00   0.00000D+00

MODE #18/ 95, Frequency (rad/sec), Damping (zeta), Generalized Mass=    65.686       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.14203D+00   0.59439D+00  -0.19324D+01  -0.46535D-01  -0.15319D-01  -0.45565D-01
Shuttle Main Engine  # 2 (left    2254     0.30886D+00   0.10938D+01  -0.13583D+01  -0.93937D-01   0.18618D-01  -0.38839D-01
Shuttle Main Engine  # 3 (righ    2091     0.48095D+00   0.10947D+01  -0.21500D+01  -0.34876D-01  -0.11836D+00   0.13099D-03
Solid Rocket Booster # 4 (left    1367     0.97530D-02   0.17959D-01  -0.81033D-02  -0.19670D-01   0.34043D-03  -0.62718D-03
Solid Rocket Booster # 5 (righ     367     0.31747D-01  -0.38837D-02  -0.48110D-02   0.22465D-01   0.87800D-05   0.44306D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372    -0.59076D-01  -0.15645D-01  -0.50991D+00  -0.34682D-01   0.50839D-02   0.27536D-02
Booster Gyro (right)               372    -0.59076D-01  -0.15645D-01  -0.50991D+00  -0.34682D-01   0.50839D-02   0.27536D-02
Booster Gyro (right)               372    -0.59076D-01  -0.15645D-01  -0.50991D+00  -0.34682D-01   0.50839D-02   0.27536D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.36805D+01  -0.53248D+01
IMU/ Accelerometer (right)        2322     0.00000D+00   0.36805D+01  -0.53248D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00   0.72320D-02   0.28448D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.15553D+00   0.10554D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00   0.72320D-02   0.28448D-01   0.00000D+00   0.00000D+00   0.00000D+00
---------------------------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Shuttle Ascent, Max_Q, T=55 sec, Flex Pitch Vehicle with Slosh and TWD
Shuttle Ascent, Max_Q, T=55 sec, Flex Vehicle with Slosh and TWD
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   1  2  3  4  5  6  7  8  9 10 21
Extract States :   3  4  7 11 12 13 14 15 16 17 18 19 20 21 22 23 24 25 26 27 28 29 30 31 32 33 34 35 36 37 38 39 40 41 42 43 44 45 46 47 49 51 53
Extract Outputs:   3  4  7 13 16 17 18 19 20 21
---------------------------------------------------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ HYDRAULIC TYPE B
Shuttle Main Engine Actuator
! Shuttle Main Engine Actuator Without Compensator 
! Using the Hydraulic Actuator Model Type (B)
Symbol       Parameter Description               (Units)     Value
C(s)   Order of Compensat:(0,1,2), Coefficients   (---)      0
Kav    Total Gain of Amplifier + Torque Motor  (ft-lb/rad)  0.91000
Kact   Power Valve and Actuator Gain .........(ft/s/ft-lb)   53.950
Kt     Piston Ram Stiffness ...................  (lb/ft)    0.20280E+07
R      Moment Arm of Actuator Ram from Gimbal    (feet)      2.4800
Ie     Engine Inertia about Gimbal ............(ft-lb-s^2)   4516.0
Be     Engine Viscous Damping .................(ft-lb-sec)   16500.
Kb     Engine Gimbal Bearing Spring Constant   (ft-lb/rad)   27160.0
Kl     Engine Mount Structural Stiffness ......  (lb/ft)    0.27960E+07
Tc     Different. Pressure Feedbk Time Constant  (seconds)  0.12660
Kdpf   Differ Pressure Feedbk Linearizat. Gain  (ft-lb/lb)  0.40400E-06
Kfb    Position Feedback Gain ................. (rad/feet)  0.4
-----------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ HYDRAULIC TYPE B
Solid Rocket Booster Actuator
Symbol       Parameter Description               (Units)     Value
C(s)   Order of Compensat:(0,1,2), Coefficients   (---)      0
Kav    Total Gain of Amplifier + Torque Motor  (ft-lb/rad)   1.8152
Kact   Power Valve and Actuator Gain .........(ft/s/ft-lb)   75.4
Kt     Piston Ram Stiffness ...................  (lb/ft)    0.45000E+07
R      Moment Arm of Actuator Ram from Gimbal    (feet)      5.8
Ie     Engine Inertia about Gimbal ............(ft-lb-s^2)   11000.0
Be     Engine Viscous Damping .................(ft-lb-sec)   17166.0
Kb     Engine Gimbal Bearing Spring Constant   (ft-lb/rad)  0.19166E+06
Kl     Engine Mount Structural Stiffness ......  (lb/ft)    0.60000E+07
Tc     Different. Pressure Feedbk Time Constant  (seconds)  0.1252
Kdpf   Differ Pressure Feedbk Linearizat. Gain  (ft-lb/lb)  0.40000E-06
Kfb    Position Feedback Gain ................. (rad/feet)  0.172
--------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Pitch Axis Discrete FCS
! Shuttle Ascent First Stage Discrete Flight Control System at Max-Q
!
Discrete, Dt= 0.04
TF. Block #  1 Loop Roll-Off                                     Order of Numer, Denom=  2  2
Numer 0.1503906  -0.0351563   0.0097656
Denom 1.000000   -1.5         0.625
TF. Block #  2 Rate Gyro Flex                                    Order of Numer, Denom=  2  2
Numer 0.3999056  -0.4957601   0.3126082
Denom 1.00000    -1.403368    0.6201218
TF. Block #  3 Nz/q-gyro Lead-Lag                                Order of Numer, Denom=  1  1
Numer 1.00       -1.0
Denom 1.00000    -0.9607843
TF. Block #  4 Nz LAG                                            Order of Numer, Denom=  1  1
Numer 0.0196078   0.0196078
Denom 1.00000    -0.9607843
TF. Block #  5 Nz Accelerom Flex                                 Order of Numer, Denom=  2  2
Numer 0.3070985  -0.419753    0.2376543
Denom 1.00000    -1.5         0.625
TF. Block #  6 Stage-1 Flex                                      Order of Numer, Denom=  2  2
Numer 0.5154625  -0.8864844   0.4788288
Denom 1.00000    -1.7157517   0.8235586
TF. Block #  7 Stage-1 Lead-Lag                                  Order of Numer, Denom=  1  1
Numer 1.3820038  -1.0422583
Denom 1.00000    -0.6602564
......................................................
Block #, from Input #, Gain
 2       1     0.24                                              KM-Theta
 2       2     1.00000                                           q-Gyro
 3       2     0.013                                             KM-QHP
 4       3     1.00000                                           Nz
...........................
Block #, from Block #, Gain
 1       7     1.00000
 7       6     1.00000
 6       2     1.00000
 6       5     29.5                                              KM-NZ
 5       3     1.00000
 5       4     1.00000
...........................
Outpt #, from Block #, Gain
 1       1     1.0                                               DQ-TVC
...........................
Definitions of Inputs  =   3
Pitch Attitude, Theta (rad)
Pitch Rate, q (rad/sec)
Normal Acceleration, Nz (ft/sec^2)
 
Definitions of Outputs =   1
Flight Control Output DQ_TVC
---------------------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Pitch Plant (Flex Vehicle, Actuators, TVC, TWD)
! Combine the Flex Pitch Vehicle with SSME and SRB Actuators and the TVC gains
! to obtain a combined plant model. The Tail-Wags-Dog effect is included.
! Load Torque feedback from the vehicle to the actuators is also used.
Titles of Systems to be Combined
Title 1 Shuttle Ascent, Max_Q, T=55 sec, Flex Pitch Vehicle with Slosh and TWD
Title 2 Shuttle Main Engine Actuator
Title 3 Solid Rocket Booster Actuator
SYSTEM INPUTS TO SUBSYSTEM  2                                    Delta-Command to SSME Actuator
System Input  1 to Subsystem  2, Input  1, Gain= 1.00000
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                    Delta-Command to SRB Actuator
System Input  1 to Subsystem  3, Input  1, Gain= 1.00000
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  1                                    Wind Gust Input
System Input  2 to Subsystem  1, Input 11, Gain= 1.00000
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                 Outputs from Vehicle
Via Matrix +I5
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                          SSME Actuator to Vehicle (TVC)
Subsystem  2, Output  1 to Subsystem  1, Input  1, Gain= 1.28
Subsystem  2, Output  1 to Subsystem  1, Input  2, Gain= 1.28
Subsystem  2, Output  1 to Subsystem  1, Input  3, Gain= 1.28
Subsystem  2, Output  3 to Subsystem  1, Input  6, Gain= 1.28
Subsystem  2, Output  3 to Subsystem  1, Input  7, Gain= 1.28
Subsystem  2, Output  3 to Subsystem  1, Input  8, Gain= 1.28
..............................................................................
SUBSYSTEM NO  3 GOES TO SUBSYSTEM NO  1                          SRB Actuator to Vehicle (TVC)
Subsystem  3, Output  1 to Subsystem  1, Input  4, Gain= 0.60000
Subsystem  3, Output  1 to Subsystem  1, Input  5, Gain= 0.60000
Subsystem  3, Output  3 to Subsystem  1, Input  9, Gain= 0.60000
Subsystem  3, Output  3 to Subsystem  1, Input 10, Gain= 0.60000
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                          Load-Torque F/B to SSME Actuator
Subsystem  1, Output  6 to Subsystem  2, Input  2, Gain= 0.3333
Subsystem  1, Output  7 to Subsystem  2, Input  2, Gain= 0.3333
Subsystem  1, Output  8 to Subsystem  2, Input  2, Gain= 0.3333
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  3                          Load-Torque F/B to SRB Actuator
Subsystem  1, Output  9 to Subsystem  3, Input  2, Gain= 0.5
Subsystem  1, Output 10 to Subsystem  3, Input  2, Gain= 0.5
..............................................................................
Definitions of Inputs  =   2
Actuator Delta-Command (rad)                                                              
Wind Gust Velocity (ft/sec)                                                              
 
Definitions of Outputs =   5
Pitch Attitude (thet-bdy) (radians)                                             
Pitch Rate     (q-body)   (rad/sec)                                             
Angle of attack, alfa, (radians)                                                
Rate-Gyro #  2, Pitch Rate (Body) (rad/sec)                                     
Accelerom #  2, (along Z), (ft/sec^2) Translat. Accelerat.                      
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Open-Loop Pitch (Plant Model + Controller)
! Combine the Discrete Plant Model (Syst.#1) with the FCS (Syst.#2) in
! Open-Loop form to use it for Nichols Frequency Domain Stability Analysis
Titles of Systems to be Combined
Title 1 Discrete Pitch Plant (Flex Vehicle, Actuators, TVC, TWD)
Title 2 Pitch Axis Discrete FCS
SYSTEM INPUTS TO SUBSYSTEM  1                                           Actuator Input
System Input  1 to Subsystem  1, Input  1, Gain= 1.0
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                        from FCS
System Output  1 from Subsystem  2, Output  1, Gain= 1.0
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                 Plant to FCS
Subsystem  1, Output  1 to Subsystem  2, Input  1, Gain=-1.00000        theta_Gyro
Subsystem  1, Output  4 to Subsystem  2, Input  2, Gain=-1.00000        q_Rate_Gyr
Subsystem  1, Output  5 to Subsystem  2, Input  3, Gain=-0.3E-03        z-dd_Accel
..............................................................................
Definitions of Inputs  =   1
Actuator Delta Pitch Command (rad)                                                              
 
Definitions of Outputs =   1
Pitch Flight Control Output                                             
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Closed Loop (Plant Model + Controller)
! Combine the Discrete Plant Model (Syst.#1) with the FCS (Syst.#2) in
! Closed-Loop form to be used in Simulations and Eigenvalue Analysis
Titles of Systems to be Combined
Title 1 Discrete Pitch Plant (Flex Vehicle, Actuators, TVC, TWD)
Title 2 Pitch Axis Discrete FCS
SYSTEM INPUTS TO SUBSYSTEM  2                                           Pitch FCS
System Input  1 to Subsystem  2, Input  1, Gain= -1.0                   Pitch Attitude Command
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  1                                           Plant Model
System Input  2 to Subsystem  1, Input  2, Gain= 1.00000                Wind Gust
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                        Closed-Loop System Outpts
Via Matrix +I5                                                          all plant outputs
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                 Vehicle to FCS Connections
Subsystem  1, Output  1 to Subsystem  2, Input  1, Gain= 1.00000        theta
Subsystem  1, Output  4 to Subsystem  2, Input  2, Gain= 1.00000        q
Subsystem  1, Output  5 to Subsystem  2, Input  3, Gain= 0.3E-03        z-dd
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                 FCS to Vehicle Connection
Subsystem  2, Output  1 to Subsystem  1, Input  1, Gain= 1.0
..............................................................................
Definitions of Inputs  =   2
Pitch Attitude Command (rad)                                                              
Wind Gust Velocity (ft/sec)                                                              
 
Definitions of Outputs =   5
Pitch Attitude (thet-bdy) (radians)                                             
Pitch Rate     (q-body)   (rad/sec)                                             
Angle of attack, alfa, (radians)                                                
Rate-Gyro #  2, Pitch Rate (Body) (rad/sec)                                     
Accelerom #  2, (along Z), (ft/sec^2) Translat. Acceleration                      
----------------------------------------------------------------------------------------------------------------------------
TRANSFORM A SYSTEM (S-Z-W) ..... (New z-system title, Comments, Old s-system title, Transform)
Discrete Pitch Plant (Flex Vehicle, Actuators, TVC, TWD)
!
! Transform the above Continuous Plant Model to Discrete using the 
! Z-Transform method and 40 msec Sampling Period
!
Pitch Plant (Flex Vehicle, Actuators, TVC, TWD) 
From S-plane to Z-plane using the Z-Transform, dT= 0.04
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Shuttle Ascent, Max_Q, T=55 sec, Flex Pitch Vehicle with Slosh and TWD                                                                                    
System
Pitch_Vehi_Flex
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Shuttle Main Engine Actuator                                                                                    
System
SSME_Actuator
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Solid Rocket Booster Actuator                                                                                    
System
SRB_Actuator
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Pitch Axis Discrete FCS                                                                                    
System
Pitch_FCS
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Pitch Plant (Flex Vehicle, Actuators, TVC, TWD)                                                                                    
System
Pitch_Plant_s
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Discrete Pitch Plant (Flex Vehicle, Actuators, TVC, TWD)                                                                                    
System
Pitch_Plant_z
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Open-Loop Pitch (Plant Model + Controller)                                                                                    
System
Open_Loop
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Closed Loop (Plant Model + Controller)                                                                                    
System
Closed_Loop
----------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
