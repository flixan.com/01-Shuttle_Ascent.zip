  4  3    1.00000                                                     to yaw loop LL filtr
  8  7    1.00000                                                     Ny accelerom flex filtr
  4  8    1.00000                                                     to Yaw LL filtr
  5  4    1.00000                                                     to yaw low-pass filtr
  7  6    1.00000
  7  9    55.0                                                        Ny accelerom load-relief gain
 11 10    1.0                                                         roll gyro LL to Flex filtr
 12 11    1.0                                                         roll flex filtr connect
 13 12    1.0                                                         flex filtr to low-pass
...........................
Outpt #, from Block #, Gain
  2  1    0.00028
  2  5    1.0                                                         DR_TVC
  1 13    1.0                                                         DP_TVC
...........................
Definitions of Inputs  =   5
Yaw attitude Error
Roll attitude Error
Yaw rate Error
Roll rate Error
Lateral Accelerometer
 
Definitions of Outputs =   2
Roll FCS Command, DP_TVC
Yaw  FCS Command, DR_TVC
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Shuttle Plant Model at Max-Q (Flex Vehicle, Actuators, Sensors)
! Combine the Flexible Vehicle with the Actuators and Sensors to create a fully coupled 
! pitch and lateral plant model. This system will be combined with the TVC and the 
! Flight Control System to create a simulation model. Tail-Wag-Dog and Load-Torque
! feedback interconnections are included.
!
Titles of Systems to be Combined
Title 1 Shuttle Ascent, Max_Q, T=55 sec, Flex Vehicle with Slosh and TWD
Title 2 System of Five Actuators
Title 3 System of Five Actuators
Title 4 IMU, Gyro, Accelerometer Sensors
SYSTEM INPUTS TO SUBSYSTEM  1                                                        Wind to Vehicle
System Input 11 to Subsystem  1, Input 21, Gain= 1.0                                 Wind-Gust
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                        Pitch Deflection Commands
System Input  1 to Subsystem  2, Input  1, Gain= 1.0                                 dy1-com
System Input  2 to Subsystem  2, Input  2, Gain= 1.0                                 dy2-com
System Input  3 to Subsystem  2, Input  3, Gain= 1.0                                 dy3-com
System Input  4 to Subsystem  2, Input  4, Gain= 1.0                                 dy4-com
System Input  5 to Subsystem  2, Input  5, Gain= 1.0                                 dy5-com
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                                        Yaw Deflection Commands
System Input  6 to Subsystem  3, Input  1, Gain= 1.0                                 dz1-com
System Input  7 to Subsystem  3, Input  2, Gain= 1.0                                 dz2-com
System Input  8 to Subsystem  3, Input  3, Gain= 1.0                                 dz3-com
System Input  9 to Subsystem  3, Input  4, Gain= 1.0                                 dz4-com
System Input 10 to Subsystem  3, Input  5, Gain= 1.0                                 dz5-com
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  4                                                     Sensors
System Output  1 from Subsystem  4, Output  1, Gain= 1.0                             roll  attitude
System Output  2 from Subsystem  4, Output  2, Gain= 1.0                             pitch attitude
System Output  3 from Subsystem  4, Output  3, Gain= 1.0                             yaw   attitude
System Output  4 from Subsystem  4, Output  4, Gain= 1.0                             roll  rate
System Output  5 from Subsystem  4, Output  5, Gain= 1.0                             pitch rate
System Output  6 from Subsystem  4, Output  6, Gain= 1.0                             yaw   rate
System Output  7 from Subsystem  4, Output  7, Gain= 1.0                             Ny Accelerat
System Output  8 from Subsystem  4, Output  8, Gain= 1.0                             Nz Accelerat
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                     Vehicle Model
System Output  9 from Subsystem  1, Output  7, Gain= 1.00000                         alpha (rad)
System Output 10 from Subsystem  1, Output  8, Gain= 1.00000                         beta  (rad)
System Output 11 from Subsystem  1, Output 17, Gain= 1.00000                         TLY-1 (ft-lb)
System Output 12 from Subsystem  1, Output 18, Gain= 1.00000                         TLY-2 (ft-lb)
System Output 13 from Subsystem  1, Output 19, Gain= 1.00000                         TLY-3 (ft-lb)
System Output 14 from Subsystem  1, Output 20, Gain= 1.00000                         TLY-4 (ft-lb)
System Output 15 from Subsystem  1, Output 21, Gain= 1.00000                         TLY-5 (ft-lb)
System Output 16 from Subsystem  1, Output 22, Gain= 1.00000                         TLZ-1 (ft-lb)
System Output 17 from Subsystem  1, Output 23, Gain= 1.00000                         TLZ-2 (ft-lb)
System Output 18 from Subsystem  1, Output 24, Gain= 1.00000                         TLZ-3 (ft-lb)
System Output 19 from Subsystem  1, Output 25, Gain= 1.00000                         TLZ-4 (ft-lb)
System Output 20 from Subsystem  1, Output 26, Gain= 1.00000                         TLZ-5 (ft-lb)
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                     Pitch Actuator Model
System Output 21 from Subsystem  2, Output  1, Gain= 1.0                             dy-1
System Output 22 from Subsystem  2, Output  2, Gain= 1.0                             dy-2
System Output 23 from Subsystem  2, Output  3, Gain= 1.0                             dy-3
System Output 24 from Subsystem  2, Output  4, Gain= 1.0                             dy-4
System Output 25 from Subsystem  2, Output  5, Gain= 1.0                             dy-5
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                                     Yaw Actuator Model
System Output 26 from Subsystem  3, Output  1, Gain= 1.0                             dz-1
System Output 27 from Subsystem  3, Output  2, Gain= 1.0                             dz-2
System Output 28 from Subsystem  3, Output  3, Gain= 1.0                             dz-3
System Output 29 from Subsystem  3, Output  4, Gain= 1.0                             dz-4
System Output 30 from Subsystem  3, Output  5, Gain= 1.0                             dz-5
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  4                                              Vehicle to Sensors
Subsystem  1, Output  1 to Subsystem  4, Input  1, Gain= 1.0                         IMU-roll
Subsystem  1, Output  3 to Subsystem  4, Input  2, Gain= 1.0                         IMU-ptch
Subsystem  1, Output  5 to Subsystem  4, Input  3, Gain= 1.0                         IMU-yaw
Subsystem  1, Output 12 to Subsystem  4, Input  4, Gain= 1.0                         Rate-Gyro-Roll
Subsystem  1, Output 13 to Subsystem  4, Input  5, Gain= 1.0                         Rate-Gyro-Ptch
Subsystem  1, Output 14 to Subsystem  4, Input  6, Gain= 1.0                         Rate-Gyro-Yaw
Subsystem  1, Output 15 to Subsystem  4, Input  7, Gain= 1.0                         Accelerom-Yddot
Subsystem  1, Output 16 to Subsystem  4, Input  8, Gain= 1.0                         Accelerom-Zddot
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                              Pitch Actuators to Vehicle
Subsystem  2, Output  1 to Subsystem  1, Input  1, Gain= 1.0                         dy-1
Subsystem  2, Output  2 to Subsystem  1, Input  2, Gain= 1.0                         dy-2
Subsystem  2, Output  3 to Subsystem  1, Input  3, Gain= 1.0                         dy-3
Subsystem  2, Output  4 to Subsystem  1, Input  4, Gain= 1.0                         dy-4
Subsystem  2, Output  5 to Subsystem  1, Input  5, Gain= 1.0                         dy-5
Subsystem  2, Output  6 to Subsystem  1, Input  6, Gain= 1.0                         dy-ddot-1
Subsystem  2, Output  7 to Subsystem  1, Input  7, Gain= 1.0                         dy-ddot-2
Subsystem  2, Output  8 to Subsystem  1, Input  8, Gain= 1.0                         dy-ddot-3
Subsystem  2, Output  9 to Subsystem  1, Input  9, Gain= 1.0                         dy-ddot-4
Subsystem  2, Output 10 to Subsystem  1, Input 10, Gain= 1.0                         dy-ddot-5
..............................................................................
SUBSYSTEM NO  3 GOES TO SUBSYSTEM NO  1                                              Yaw Actuators to Vehicle
Subsystem  3, Output  1 to Subsystem  1, Input 11, Gain= 1.0                         dz-1
Subsystem  3, Output  2 to Subsystem  1, Input 12, Gain= 1.0                         dz-2
Subsystem  3, Output  3 to Subsystem  1, Input 13, Gain= 1.0                         dz-3
Subsystem  3, Output  4 to Subsystem  1, Input 14, Gain= 1.0                         dz-4
Subsystem  3, Output  5 to Subsystem  1, Input 15, Gain= 1.0                         dz-5
Subsystem  3, Output  6 to Subsystem  1, Input 16, Gain= 1.0                         dz-ddot-1
Subsystem  3, Output  7 to Subsystem  1, Input 17, Gain= 1.0                         dz-ddot-2
Subsystem  3, Output  8 to Subsystem  1, Input 18, Gain= 1.0                         dz-ddot-3
Subsystem  3, Output  9 to Subsystem  1, Input 19, Gain= 1.0                         dz-ddot-4
Subsystem  3, Output 10 to Subsystem  1, Input 20, Gain= 1.0                         dz-ddot-5
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                              Pitch Load-Torque Feedback
Subsystem  1, Output 17 to Subsystem  2, Input  6, Gain= 1.0                         TLY-1
Subsystem  1, Output 18 to Subsystem  2, Input  7, Gain= 1.0                         TLY-2
Subsystem  1, Output 19 to Subsystem  2, Input  8, Gain= 1.0                         TLY-3
Subsystem  1, Output 20 to Subsystem  2, Input  9, Gain= 1.0                         TLY-4
Subsystem  1, Output 21 to Subsystem  2, Input 10, Gain= 1.0                         TLY-5
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  3                                              Yaw Load-Torque Feedback
Subsystem  1, Output 22 to Subsystem  3, Input  6, Gain= 1.0                         TLZ-1
Subsystem  1, Output 23 to Subsystem  3, Input  7, Gain= 1.0                         TLZ-2
Subsystem  1, Output 24 to Subsystem  3, Input  8, Gain= 1.0                         TLZ-3
Subsystem  1, Output 25 to Subsystem  3, Input  9, Gain= 1.0                         TLZ-4
Subsystem  1, Output 26 to Subsystem  3, Input 10, Gain= 1.0                         TLZ-5
..............................................................................
Definitions of Inputs  =  11
Engine# 1 Ptch Deflect Command dy-1 (rad)  
Engine# 2 Ptch Deflect Command dy-2 (rad)  
Engine# 3 Ptch Deflect Command dy-3 (rad)  
Engine# 4 Ptch Deflect Command dy-4 (rad)  
Engine# 5 Ptch Deflect Command dy-5 (rad)  
Engine# 1 Yaw  Deflect Command dz-1 (rad)  
Engine# 2 Yaw  Deflect Command dz-2 (rad)  
Engine# 3 Yaw  Deflect Command dz-3 (rad)  
Engine# 4 Yaw  Deflect Command dz-4 (rad)  
Engine# 5 Yaw  Deflect Command dz-5 (rad)  
Wind Gust Velocity (ft/sec)                                                              
 
Definitions of Outputs =  30
Roll Attitude  (phi-body) (radians)   
Pitch Attitude (thet-bdy) (radians)     
Yaw  Attitude  (psi-body) (radians)    
Roll Rate Gyro  (p-flex)  (rad/sec)                   
Pitch Rate Gyro (q-flex)  (rad/sec)                    
Yaw  Rate Gyro  (r-flex)  (rad/sec)                                                                                                                                          
Accelerom #  1, Y-ddot Accelerat. (ft/sec^2)  
Accelerom #  2, Z-ddot Accelerat. (ft/sec^2)  
Angle of attack, alfa, (radians)                                                                                                                                             
Angle of sideslip, beta, (radian)                                                                                                                                            
Load-Torque Pitch TLY-Eng-1
Load-Torque Pitch TLY-Eng-2
Load-Torque Pitch TLY-Eng-3
Load-Torque Pitch TLY-Eng-4
Load-Torque Pitch TLY-Eng-5
Load-Torque Yaw   TLZ-Eng-1
Load-Torque Yaw   TLZ-Eng-2
Load-Torque Yaw   TLZ-Eng-3
Load-Torque Yaw   TLZ-Eng-4
Load-Torque Yaw   TLZ-Eng-5
Engine # 1 Pitch Deflection dy-1 (rad)
Engine # 2 Pitch Deflection dy-2 (rad)
Engine # 3 Pitch Deflection dy-3 (rad)
Engine # 4 Pitch Deflection dy-4 (rad)
Engine # 5 Pitch Deflection dy-5 (rad)
Engine # 1 Yaw   Deflection dz-1 (rad)
Engine # 2 Yaw   Deflection dz-2 (rad)
Engine # 3 Yaw   Deflection dz-3 (rad)
Engine # 4 Yaw   Deflection dz-4 (rad)
Engine # 5 Yaw   Deflection dz-5 (rad)
----------------------------------------------------------------------------------------------------------------------------
TRANSFORM A SYSTEM (S-Z-W) ..... (New z-system title, Comments, Old s-system title, Transform)
Discrete Shuttle Plant Model at Max-Q (Flex Vehicle, Actuators, Sensors)
! Transform the continuous Plant Model created above to discrete using the 
! S to Z Transformation method and 40 msec Sampling Period
!
Shuttle Plant Model at Max-Q (Flex Vehicle, Actuators, Sensors) 
From S-plane to Z-plane using the Z-Transform, dT= 0.04
----------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Wind Gust Shaping
! This is a low-pass filter for shaping the wind-gust pulse
!
Discrete, dt=  0.04
TF. Block #  1 0.5^2/(s^2 +0.5s +0.5^2)                          Order of Numer, Denom=  2  2
Numer 0.0         0.0001987  0.0001973
Denom 1.00000    -1.98       0.9802
......................................................
Block #, from Input #, Gain
  1  1    1.0                             
...........................
Outpt #, from Block #, Gain
  1  1    1.0
...........................
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Open-Loop System (Plant + FCS)
! Combine the discretized Plant model with the Pitch and Lateral flight control systems and
! the TVC in open-loop form for frequency response analysis.
!
Titles of Systems to be Combined
Title 1 Discrete Shuttle Plant Model at Max-Q (Flex Vehicle, Actuators, Sensors)
Title 2 Pitch Axis Discrete FCS
Title 3 Lateral Axes Discrete FCS (Roll/Yaw)
Title 4 Wind Gust Shaping
SYSTEM INPUTS TO SUBSYSTEM  1                                                        TVC to Vehicle
Via Matrix +TVC                                                                      roll, pitch, yaw
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  4                                                        Wind to Shaper
System Input  4 to Subsystem  4, Input  1, Gain= 1.0                                 Wind-Gust
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                        Pitch Command
System Input  6 to Subsystem  2, Input  1, Gain= -1.0                                Theta Command
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                                        Lateral Commands
System Input  7 to Subsystem  3, Input  1, Gain= -1.0                                Psi Command
System Input  5 to Subsystem  3, Input  2, Gain= -1.0                                Phi Command
..............................................................................
SUBSYSTEM NO  4 GOES TO SUBSYSTEM NO  1                                              Gust to Vehicle
Subsystem  4, Output  1 to Subsystem  1, Input 11, Gain= 1.0                         Shaper to Gust Input
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                              Pitch Outputs to FCS
Subsystem  1, Output  2 to Subsystem  2, Input  1, Gain= 1.0                         pitch attitude
Subsystem  1, Output  5 to Subsystem  2, Input  2, Gain= 1.0                         pitch rate
Subsystem  1, Output  8 to Subsystem  2, Input  3, Gain= 0.0003                      Nz accelerat
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  3                                              Lateral Outputs to FCS
Subsystem  1, Output  3 to Subsystem  3, Input  1, Gain= 1.0                         yaw attitude
Subsystem  1, Output  1 to Subsystem  3, Input  2, Gain= 1.0                         roll attitude
Subsystem  1, Output  6 to Subsystem  3, Input  3, Gain= 1.0                         yaw rate
Subsystem  1, Output  4 to Subsystem  3, Input  4, Gain= 1.0                         roll rate
Subsystem  1, Output  7 to Subsystem  3, Input  5, Gain= 0.00054                     Ny accelerat
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                     from Plant
Via Matrix +I30                                                                      All Outputs
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                     Pitch FCS
System Output 32 from Subsystem  2, Output  1, Gain= 1.0                             DQ-TVC
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                                     Lateral FCS
System Output 31 from Subsystem  3, Output  1, Gain= 1.0                             DP-TVC
System Output 33 from Subsystem  3, Output  2, Gain= 1.0                             DR-TVC
..............................................................................
Definitions of Inputs  =   7
DP_TVC (roll FCS demand input)      
DQ_TVC (pitch FCS demand input)   
DR_TVC (yaw FCS demand input)   
Wind Gust Velocity (ft/sec)     
Phi Attitude Command (rad)
Theta Attitude Command (rad)
Psi Attitude Command (rad)

Definitions of Outputs =  33
Roll Attitude  (phi-body) (radians)   
Pitch Attitude (thet-bdy) (radians)     
Yaw  Attitude  (psi-body) (radians)    
Roll Rate Gyro  (p-flex)  (rad/sec)                   
Pitch Rate Gyro (q-flex)  (rad/sec)                    
Yaw  Rate Gyro  (r-flex)  (rad/sec)     
Accelerom #  1, Y-ddot Accelerat. (ft/sec^2)  
Accelerom #  2, Z-ddot Accelerat. (ft/sec^2)  
Angle of attack, alfa, (radians)        
Angle of sideslip, beta, (radian)    
Load-Torque Pitch TLY-Eng-1
Load-Torque Pitch TLY-Eng-2
Load-Torque Pitch TLY-Eng-3
Load-Torque Pitch TLY-Eng-4
Load-Torque Pitch TLY-Eng-5
Load-Torque Yaw   TLZ-Eng-1
Load-Torque Yaw   TLZ-Eng-2
Load-Torque Yaw   TLZ-Eng-3
Load-Torque Yaw   TLZ-Eng-4
Load-Torque Yaw   TLZ-Eng-5
Engine # 1 Pitch Deflection dy-1 (rad)
Engine # 2 Pitch Deflection dy-2 (rad)
Engine # 3 Pitch Deflection dy-3 (rad)
Engine # 4 Pitch Deflection dy-4 (rad)
Engine # 5 Pitch Deflection dy-5 (rad)
Engine # 1 Yaw   Deflection dz-1 (rad)
Engine # 2 Yaw   Deflection dz-2 (rad)
Engine # 3 Yaw   Deflection dz-3 (rad)
Engine # 4 Yaw   Deflection dz-4 (rad)
Engine # 5 Yaw   Deflection dz-5 (rad)
DP_TVC (roll FCS demand output)       
DQ_TVC (pitch FCS demand output)          
DR_TVC (yaw FCS demand output)                      
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Shuttle Stage-1 TVC Matrix at Max-Q                                                                                    
Matrix TVC
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Shuttle Ascent, Max_Q, T=55 sec (Rigid Body)                                                                                    
System
Vehicle_rb
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Shuttle Ascent, Max_Q, T=55 sec, Flex Vehicle with Slosh and TWD                                                                                    
System
Vehicle_flex_s
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Shuttle Main Engine Actuator                                                                                    
System
Actuator_ssme
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Solid Rocket Booster Actuator                                                                                    
System
Actuator_srb
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Pitch Axis Discrete FCS                                                                                    
System
Pitch_fcs
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Lateral Axes Discrete FCS (Roll/Yaw)                                                                                    
System
Lateral_fcs
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
System of Five Actuators      
System
Actuators_5s
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Shuttle Plant Model at Max-Q (Flex Vehicle, Actuators, Sensors)
System
Vehi_Plant_s
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Shuttle Ascent, Max_Q, T=55 sec, Flex Vehicle with Slosh and TWD, Z-transform
System
Vehicle_flex_z
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Discrete Shuttle Plant Model at Max-Q (Flex Vehicle, Actuators, Sensors)
System
Vehi_Plant_z
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
System of Five Actuators, Z-Transform
System
Actuators_5z
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
IMU, Gyro, Accelerometer Sensors, Z-transform
System
Sensors_z
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Open-Loop System (Plant + FCS)
System
Open_Loop
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
