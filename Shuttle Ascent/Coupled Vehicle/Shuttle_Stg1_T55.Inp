BATCH MODE INSTRUCTIONS ...............                                                             
Batch for preparing the Shuttle Ascent, First Stage Max-Q, Coupled Axes Models
! This batch set creates Space Shuttle Ascent models at Max Dynamic Pressure which occurs 55
! seconds after lift-off. A rigid-body model is created and a flexible model with 29 mixed 
! symmetric and anti-symmetric flex modes. Fuel sloshing for the External Tank is also included 
! in the flex model and the tail-wags-dog option is turned on. Two actuator models are created, 
! an SSME and an SRB, and they are combined together to form a system of 5 actuators, one for each 
! TVC engine. Two sets of 5 actuator subsystems are required, for pitch engine deflections (dy), 
! and for yaw deflections (dz). The sensor dynamics are also included. The pitch and lateral 
! flight control systems are contructed in the z-domain with 40 msec sampling period. Flex vehicle, 
! actuators, and sensors are combined together to create a coupled continuous plant model which is 
! also discretized at 40 msec. The created systems are converted to Matlab format for analysis.
!
Retain Matrix    : Shuttle Stage-1 TVC Matrix at Max-Q
Flight Vehicle   : Shuttle Ascent, Max_Q, T=55 sec (Rigid Body)                
Flight Vehicle   : Shuttle Ascent, Max_Q, T=55 sec, Flex Vehicle with Slosh and TWD          
Actuator Model   : Shuttle Main Engine Actuator
Actuator Model   : Solid Rocket Booster Actuator
Transf-Function  : Pitch Axis Discrete FCS
Transf-Function  : Lateral Axes Discrete FCS (Roll/Yaw) 
Transf-Function  : Wind Gust Shaping
System Connection: System of Five Actuators  
Transf-Function  : IMU, Gyro, Accelerometer Sensors
System Connection: Shuttle Plant Model at Max-Q (Flex Vehicle, Actuators, Sensors)
S-Z-Transform    : Shuttle Ascent, Max_Q, T=55 sec, Flex Vehicle with Slosh and TWD, Z-transform
S-Z-Transform    : Discrete Shuttle Plant Model at Max-Q (Flex Vehicle, Actuators, Sensors)
S-Z-Transform    : System of Five Actuators, Z-Transform
S-Z-Transform    : IMU, Gyro, Accelerometer Sensors, Z-transform
System Connection: Open-Loop System (Plant + FCS)
To Matlab Format : Shuttle Stage-1 TVC Matrix at Max-Q
To Matlab Format : Shuttle Ascent, Max_Q, T=55 sec (Rigid Body)
To Matlab Format : Shuttle Ascent, Max_Q, T=55 sec, Flex Vehicle with Slosh and TWD
To Matlab Format : Shuttle Main Engine Actuator
To Matlab Format : Solid Rocket Booster Actuator
To Matlab Format : Pitch Axis Discrete FCS
To Matlab Format : Lateral Axes Discrete FCS (Roll/Yaw)
To Matlab Format : System of Five Actuators      
To Matlab Format : Shuttle Plant Model at Max-Q (Flex Vehicle, Actuators, Sensors)
To Matlab Format : Shuttle Ascent, Max_Q, T=55 sec, Flex Vehicle with Slosh and TWD, Z-transform
To Matlab Format : Discrete Shuttle Plant Model at Max-Q (Flex Vehicle, Actuators, Sensors)
To Matlab Format : System of Five Actuators, Z-Transform
To Matlab Format : IMU, Gyro, Accelerometer Sensors, Z-transform
To Matlab Format : Open-Loop System (Plant + FCS)
------------------------------------------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Shuttle Ascent, Max_Q, T=55 sec (Rigid Body)
! Rigid Body Shuttle Model during First Stage at Max Dynamic pressure. 
! Slosh, Bending, and Tail-Wag-Dog is Not Included.
Body Axes Output, Attitude=Rate Integral,Without GAFD, No Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Planet Radius (Re) (ft)   :   0.1093E+6    32.174       0.20896E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   0.27E+8      0.22E+9      0.234E+9     0.5e5,       0.9e7,       0.3e5    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   83.98        0.0         -2.18
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   1.4          1400.0       600.0        37000.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   52.0         49.66        0.0000       4.0    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  -4.1         -0.15         0.0          0.0    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0000       65.7         0.0000       0.0000       0.0000       0.0000    
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:   Gust         45.0         90.0    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   2690.0       15.0         15.0  
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   83.98        0.0         -2.18        -9.482e-10
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.0         -0.00046      0.0          0.0          0.0          0.0000      -0.00054    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0         -0.027        0.0000       0.0012       0.0000       0.0000       0.0000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:   0.0         -0.035        0.0000      -0.0047       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.0         -0.028        0.0000       0.0000       0.0000      -0.0007
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:   0.0         -0.01         0.0000      -0.004        0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0          0.0247       0.0000       0.0000       0.0000       0.0015    

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  0   NO TWD  

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  5   NO TWD

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Middle SSME      Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  275000.0     275000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -16.0         0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0        4032.0        3.0   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  19.0         0.0          -32.0    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : Left SSME        Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  275000.0     275000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -10.0         0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0        4032.0        3.0   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  17.0        -4.5          -23.0    
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : Right SSME       Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  275000.0     275000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -10.0         0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0        4032.0        3.0   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  17.0         4.5          -23.0    
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : Left SRB         Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.23e+7      0.23e+7
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0          0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  540.0        0.12e+5      -0.7   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  0.0         -21.0          0.0    
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : Left SRB         Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.23e+7      0.23e+7
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0          0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  540.0        0.12e+5      -0.7   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  0.0         +21.0          0.0    

Number of Gyros, (Attitude and Rate)                                                     :  0

Number of Accelerometers, Along Axis: (x,y,z)                                            :  0

Number of Vane Sensors, (Measuring Alpha or Beta)                                        :  0

Number of Slosh Modes                                                                    :  0

Number of Bending Modes                                                                  :  0
                                                                                                    
---------------------------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Shuttle Ascent, Max_Q, T=55 sec, Flex Vehicle with Slosh and TWD
! Flexible Shuttle vehicle model during First Stage at Max Dynamic pressure. 
! Slosh due to LOX and LH2 fuel tanks, and Tail-Wag-Dog is included.
! Only 12 Lateral structural modes were selected
Body Axes Output, Attitude=Rate Integral,Without GAFD, No Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Planet Radius (Re) (ft)   :   0.1093E+6    32.174       0.20896E+08
Moments and Products of Inertia: Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :   0.27E+8      0.22E+9      0.234E+9     0.5e5,       0.9e7,       0.3e5    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :   83.98        0.0         -2.18
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :   1.4          1400.0       600.0        37000.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :   52.0         49.66        0.0000       4.0    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :  -4.1         -0.15         0.0          0.0    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0000       65.7         0.0000       0.0000       0.0000       0.0000    
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:   Gust         45.0         90.0    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   2690.0       15.0         15.0  
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :   83.98        0.0         -2.18        -9.482e-10
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:   0.0         -0.00046      0.0          0.0          0.0          0.0000      -0.00054    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0         -0.027        0.0000       0.0012       0.0000       0.0000       0.0000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:   0.0         -0.035        0.0000      -0.0047       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.0         -0.028        0.0000       0.0000       0.0000      -0.0007
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}:   0.0         -0.01         0.0000      -0.004        0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0          0.0247       0.0000       0.0000       0.0000       0.0015    

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  0   NO TWD  

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  5   WITH TWD

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : Middle SSME      Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  275000.0     275000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -16.0         0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0        4032.0        3.0   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  19.0         0.0          -32.0    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : Left SSME        Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  275000.0     275000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -10.0         0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0        4032.0        3.0   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  17.0        -4.5          -23.0    
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : Right SSME       Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  275000.0     275000.0
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -10.0         0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0        4032.0        3.0   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  17.0         4.5          -23.0    
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : Left SRB         Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.23e+7      0.23e+7
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0          0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  540.0        0.12e+5      -0.7   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  0.0         -21.0          0.0    
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : Left SRB         Gimbaling             
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.23e+7      0.23e+7
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg):  0.0          0.0           10.0        10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  540.0        0.12e+5      -0.7   
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) :  0.0         +21.0          0.0    

Number of Gyros, (Attitude and Rate)                                                     :  3
Gyro No  1 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Roll   Rate            108.3      0.00      -28.00    
Gyro No  2 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Pitch  Rate            108.3      0.00      -28.00    
Gyro No  3 Axis:(Pitch,Yaw,Roll), (Attitude, Rate, Accelerat), Sensor Location in (feet) :  Yaw    Rate            108.3      0.00      -28.00    

Number of Accelerometers, Along Axis: (x,y,z)                                            :  2
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.      108.3      0.00      -28.00    
Acceleromet No  2 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.      108.3      0.00      -28.00    

Number of Vane Sensors, (Measuring Alpha or Beta)                                        :  0

Number of Slosh Modes                                                                    :  2
LOX Slosh Mass (slug), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft) :  3064.0   2.428  2.428  0.0015  0.0015  143.00   0.0    0.0    
LH2 Slosh Mass (slug), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft) :  512.0    2.058  2.058  0.0018  0.0018   87.00   0.0    0.0   

Number of Bending Modes                                                                  : 29
Flex Modes for Shuttle Ascent, Max_Q, T=55 sec
---------------------------------------------------------------------------------------------------------------------------------------------
SELECTED MODAL DATA AND LOCATIONS FOR SHUTTLE ASCENT AT MAX-Q
Flex Modes for Shuttle Ascent, Max_Q, T=55 sec
! The following set of 29 flex modes include both symmetric (pitch) and anti-symmetric (lateral)
! modes. They were selected using the mode-selection process.

MODE # 1/  7, Frequency (rad/sec), Damping (zeta), Generalized Mass=    12.151       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.61387D+00  -0.61734D-01  -0.15612D+01   0.42653D-02  -0.13384D-01   0.11436D-02
Shuttle Main Engine  # 2 (left    2254     0.50962D+00  -0.91117D-01  -0.15971D+01   0.29002D-02  -0.13111D-01  -0.75217D-03
Shuttle Main Engine  # 3 (righ    2091     0.50867D+00  -0.92870D-01  -0.15757D+01   0.44489D-02  -0.23288D-01   0.15293D-02
Solid Rocket Booster # 4 (left    1367    -0.44066D-01   0.13004D+00  -0.78224D+00  -0.17006D+00  -0.25292D-01  -0.64782D-03
Solid Rocket Booster # 5 (righ     367    -0.31986D-01  -0.13981D+00  -0.78234D+00   0.17183D+00  -0.25481D-01   0.11537D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372    -0.18730D-01   0.10486D+01   0.88193D+00   0.19468D+00  -0.99742D-03   0.14856D-02
Booster Gyro (right)               372    -0.18730D-01   0.10486D+01   0.88193D+00   0.19468D+00  -0.99742D-03   0.14856D-02
Booster Gyro (right)               372    -0.18730D-01   0.10486D+01   0.88193D+00   0.19468D+00  -0.99742D-03   0.14856D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.39853D-01  -0.23900D+00
IMU/ Accelerometer (right)        2322     0.00000D+00   0.39853D-01  -0.23900D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.83451D-02  -0.68063D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00   0.93311D-02  -0.37481D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.83451D-02  -0.68063D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE # 2/  8, Frequency (rad/sec), Damping (zeta), Generalized Mass=    12.778       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.91664D-02   0.18723D+01  -0.16686D-01   0.95388D-01  -0.38999D-02  -0.15823D-01
Shuttle Main Engine  # 2 (left    2254     0.14771D+00   0.93867D+00  -0.35851D+00   0.82810D-01   0.19854D-01   0.33026D-01
Shuttle Main Engine  # 3 (righ    2091    -0.14020D+00   0.94628D+00   0.35008D+00   0.76428D-01   0.12912D-01   0.25309D-01
Solid Rocket Booster # 4 (left    1367     0.20309D+00   0.26632D+00  -0.28703D+00  -0.91805D-01  -0.11800D-01  -0.11624D-01
Solid Rocket Booster # 5 (righ     367    -0.20439D+00   0.25900D+00   0.25654D+00  -0.87006D-01   0.10924D-01  -0.11574D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372    -0.18763D+00  -0.98496D+00  -0.37473D+00  -0.97034D-01  -0.61992D-02   0.38462D-02
Booster Gyro (right)               372    -0.18763D+00  -0.98496D+00  -0.37473D+00  -0.97034D-01  -0.61992D-02   0.38462D-02
Booster Gyro (right)               372    -0.18763D+00  -0.98496D+00  -0.37473D+00  -0.97034D-01  -0.61992D-02   0.38462D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.27026D+01   0.12267D+00
IMU/ Accelerometer (right)        2322     0.00000D+00   0.27026D+01   0.12267D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00   0.25308D+00  -0.11050D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.25045D+00  -0.49152D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00   0.25308D+00  -0.11050D-01   0.00000D+00   0.00000D+00   0.00000D+00

MODE # 3/  9, Frequency (rad/sec), Damping (zeta), Generalized Mass=    13.248       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088    -0.50581D-02  -0.19327D+00   0.73092D-02   0.29644D-01  -0.47701D-03   0.11946D-01
Shuttle Main Engine  # 2 (left    2254     0.12470D+00  -0.52147D+00  -0.94173D-01   0.24821D-01   0.75034D-02   0.29069D-01
Shuttle Main Engine  # 3 (righ    2091    -0.13192D+00  -0.52026D+00   0.11794D+00   0.23718D-01   0.31734D-02   0.27880D-01
Solid Rocket Booster # 4 (left    1367    -0.54729D+00  -0.18949D+01  -0.12509D+00  -0.28037D-01  -0.40825D-02   0.44090D-01
Solid Rocket Booster # 5 (righ     367     0.54914D+00  -0.18857D+01   0.13444D+00  -0.29456D-01   0.43848D-02   0.44036D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.53280D+00   0.96020D+00  -0.10734D+00  -0.38900D-01   0.97733D-02   0.63764D-03
Booster Gyro (right)               372     0.53280D+00   0.96020D+00  -0.10734D+00  -0.38900D-01   0.97733D-02   0.63764D-03
Booster Gyro (right)               372     0.53280D+00   0.96020D+00  -0.10734D+00  -0.38900D-01   0.97733D-02   0.63764D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.21160D+01   0.53141D-01
IMU/ Accelerometer (right)        2322     0.00000D+00   0.21160D+01   0.53141D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.92840D+00   0.45862D-02   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00   0.78407D+00   0.59360D-03   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.92840D+00   0.45862D-02   0.00000D+00   0.00000D+00   0.00000D+00

MODE # 4/ 10, Frequency (rad/sec), Damping (zeta), Generalized Mass=    15.140       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.21481D+01  -0.12488D-01  -0.12885D+01  -0.76709D-03  -0.10757D+00   0.23267D-03
Shuttle Main Engine  # 2 (left    2254     0.12522D+01   0.63631D-02  -0.14857D+01  -0.15500D-02  -0.10868D+00  -0.31345D-02
Shuttle Main Engine  # 3 (righ    2091     0.12599D+01   0.42062D-03  -0.15161D+01  -0.24712D-03  -0.12589D+00   0.23136D-02
Solid Rocket Booster # 4 (left    1367    -0.71271D-01  -0.19005D+00  -0.60001D+00   0.31932D-01  -0.12724D-01   0.24388D-02
Solid Rocket Booster # 5 (righ     367    -0.70664D-01   0.18430D+00  -0.61031D+00  -0.30578D-01  -0.12991D-01  -0.22746D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372    -0.59885D-01  -0.13794D+00   0.29224D+00  -0.26555D-01   0.36988D-05  -0.10557D-02
Booster Gyro (right)               372    -0.59885D-01  -0.13794D+00   0.29224D+00  -0.26555D-01   0.36988D-05  -0.10557D-02
Booster Gyro (right)               372    -0.59885D-01  -0.13794D+00   0.29224D+00  -0.26555D-01   0.36988D-05  -0.10557D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.40880D-01   0.13408D+01
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.40880D-01   0.13408D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.39555D-03  -0.70534D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.70712D-03   0.84404D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.39555D-03  -0.70534D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE # 5/ 11, Frequency (rad/sec), Damping (zeta), Generalized Mass=    15.693       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088    -0.12992D+01  -0.66250D-02   0.60877D+00   0.28522D-03   0.56108D-01   0.68663D-04
Shuttle Main Engine  # 2 (left    2254    -0.82874D+00  -0.16774D-01   0.71381D+00   0.48283D-03   0.57134D-01   0.21515D-02
Shuttle Main Engine  # 3 (righ    2091    -0.83395D+00  -0.12642D-01   0.72895D+00   0.38161D-05   0.66695D-01  -0.14364D-02
Solid Rocket Booster # 4 (left    1367     0.68673D-01   0.17918D+00   0.46836D+00  -0.32081D-01   0.10253D-01  -0.25210D-02
Solid Rocket Booster # 5 (righ     367     0.68352D-01  -0.17160D+00   0.42289D+00   0.30661D-01   0.92213D-02   0.23298D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.62085D-01   0.15116D+00  -0.20092D+00   0.28375D-01  -0.68186D-03   0.69469D-03
Booster Gyro (right)               372     0.62085D-01   0.15116D+00  -0.20092D+00   0.28375D-01  -0.68186D-03   0.69469D-03
Booster Gyro (right)               372     0.62085D-01   0.15116D+00  -0.20092D+00   0.28375D-01  -0.68186D-03   0.69469D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.40106D-01  -0.89821D+00
IMU/ Accelerometer (right)        2322     0.00000D+00   0.40106D-01  -0.89821D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00   0.57850D-04   0.50328D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00   0.10319D-02  -0.68601D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00   0.57850D-04   0.50328D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE # 6/ 12, Frequency (rad/sec), Damping (zeta), Generalized Mass=    15.756       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088    -0.57191D-02   0.10079D+01   0.51397D-02   0.20531D-01  -0.56238D-03  -0.11015D-01
Shuttle Main Engine  # 2 (left    2254    -0.61803D-01   0.87407D+00  -0.91006D-01   0.22082D-01  -0.82698D-03  -0.12947D-01
Shuttle Main Engine  # 3 (righ    2091     0.55587D-01   0.87720D+00   0.10369D+00   0.19643D-01   0.34308D-02  -0.16159D-01
Solid Rocket Booster # 4 (left    1367    -0.11262D-02  -0.93065D-01  -0.26722D+01   0.45787D-01  -0.61252D-01   0.24362D-02
Solid Rocket Booster # 5 (righ     367     0.14942D-02  -0.92096D-01   0.26776D+01   0.45883D-01   0.61379D-01   0.24551D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.84253D-02   0.16559D+00  -0.11638D+01   0.14873D-01  -0.27221D-02   0.37985D-03
Booster Gyro (right)               372     0.84253D-02   0.16559D+00  -0.11638D+01   0.14873D-01  -0.27221D-02   0.37985D-03
Booster Gyro (right)               372     0.84253D-02   0.16559D+00  -0.11638D+01   0.14873D-01  -0.27221D-02   0.37985D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.18189D+01  -0.21033D-01
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.18189D+01  -0.21033D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00   0.30489D-01   0.22297D-02   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.36157D-01  -0.20524D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00   0.30489D-01   0.22297D-02   0.00000D+00   0.00000D+00   0.00000D+00

MODE # 7/ 13, Frequency (rad/sec), Damping (zeta), Generalized Mass=    16.090       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.79857D+00  -0.15479D-02  -0.66802D+00  -0.55618D-02  -0.26927D-01  -0.87260D-03
Shuttle Main Engine  # 2 (left    2254     0.56772D+00   0.54210D-01  -0.69196D+00  -0.61384D-02  -0.27682D-01  -0.29850D-02
Shuttle Main Engine  # 3 (righ    2091     0.58298D+00   0.51071D-01  -0.75369D+00  -0.51469D-02  -0.37168D-01   0.32990D-04
Solid Rocket Booster # 4 (left    1367    -0.21954D+00   0.33113D+00   0.39007D+00   0.45670D-02   0.94889D-02   0.19432D-01
Solid Rocket Booster # 5 (righ     367    -0.21882D+00  -0.35914D+00   0.39940D+00  -0.79291D-03   0.96940D-02  -0.18802D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372    -0.17451D+00  -0.58460D+00  -0.19526D+00   0.14174D-02  -0.19996D-01   0.34300D-01
Booster Gyro (right)               372    -0.17451D+00  -0.58460D+00  -0.19526D+00   0.14174D-02  -0.19996D-01   0.34300D-01
Booster Gyro (right)               372    -0.17451D+00  -0.58460D+00  -0.19526D+00   0.14174D-02  -0.19996D-01   0.34300D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.14423D+00   0.14354D-01
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.14423D+00   0.14354D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.13477D-02   0.15323D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.24757D-02  -0.12438D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.13477D-02   0.15323D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE # 8/ 14, Frequency (rad/sec), Damping (zeta), Generalized Mass=    17.181       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.59364D-01   0.19260D+01  -0.36220D-01   0.11113D+00  -0.53036D-02   0.16080D-01
Shuttle Main Engine  # 2 (left    2254     0.19659D+00   0.90344D+00  -0.49887D+00   0.10728D+00   0.54991D-02   0.34933D-01
Shuttle Main Engine  # 3 (righ    2091    -0.10220D+00   0.91317D+00   0.43509D+00   0.98844D-01   0.11862D-01   0.24767D-01
Solid Rocket Booster # 4 (left    1367    -0.28276D-01  -0.94330D-02   0.21849D+00  -0.10661D+00   0.48041D-02  -0.76717D-03
Solid Rocket Booster # 5 (righ     367     0.10777D-01   0.95459D-01  -0.17090D+00  -0.10890D+00  -0.34576D-02  -0.41825D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.11684D-01  -0.71570D+00   0.16517D+00  -0.11455D+00  -0.24780D-02   0.27070D-02
Booster Gyro (right)               372     0.11684D-01  -0.71570D+00   0.16517D+00  -0.11455D+00  -0.24780D-02   0.27070D-02
Booster Gyro (right)               372     0.11684D-01  -0.71570D+00   0.16517D+00  -0.11455D+00  -0.24780D-02   0.27070D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.45283D+01   0.19538D+00
IMU/ Accelerometer (right)        2322     0.00000D+00   0.45283D+01   0.19538D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.25673D-01   0.32536D-02   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00   0.10840D+00   0.14504D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.25673D-01   0.32536D-02   0.00000D+00   0.00000D+00   0.00000D+00

MODE # 9/ 15, Frequency (rad/sec), Damping (zeta), Generalized Mass=    18.177       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.95973D+00   0.83257D-02  -0.16053D+01   0.26111D-02  -0.64025D-01   0.75128D-03
Shuttle Main Engine  # 2 (left    2254     0.45384D+00   0.25019D-03  -0.17131D+01  -0.50723D-03  -0.61160D-01  -0.23294D-02
Shuttle Main Engine  # 3 (righ    2091     0.45965D+00  -0.31172D-02  -0.17332D+01   0.26284D-02  -0.87218D-01   0.21815D-02
Solid Rocket Booster # 4 (left    1367     0.56472D-01   0.16644D+01   0.11862D+01  -0.99252D-01   0.31171D-01  -0.41490D-01
Solid Rocket Booster # 5 (righ     367     0.57456D-01  -0.16596D+01   0.11897D+01   0.97726D-01   0.31244D-01   0.41359D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.10708D+00   0.83581D+00  -0.36541D+00   0.80592D-01   0.13846D-02  -0.10854D-01
Booster Gyro (right)               372     0.10708D+00   0.83581D+00  -0.36541D+00   0.80592D-01   0.13846D-02  -0.10854D-01
Booster Gyro (right)               372     0.10708D+00   0.83581D+00  -0.36541D+00   0.80592D-01   0.13846D-02  -0.10854D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.42075D-01  -0.79261D+00
IMU/ Accelerometer (right)        2322     0.00000D+00   0.42075D-01  -0.79261D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00   0.26556D-04   0.83193D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00   0.18277D-02  -0.11793D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00   0.26556D-04   0.83193D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE #10/ 16, Frequency (rad/sec), Damping (zeta), Generalized Mass=    18.848       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088    -0.23209D+00  -0.10458D+00  -0.20549D+00   0.36372D-02  -0.83291D-02   0.73218D-03
Shuttle Main Engine  # 2 (left    2254    -0.28635D+00  -0.13484D+00  -0.22837D+00   0.27263D-02  -0.61628D-02   0.10002D-02
Shuttle Main Engine  # 3 (righ    2091    -0.29097D+00  -0.13344D+00  -0.20182D+00   0.35764D-02  -0.78791D-02   0.43192D-03
Solid Rocket Booster # 4 (left    1367    -0.64847D-01  -0.25838D+01   0.47520D+00  -0.82202D-01   0.13514D-01   0.57914D-01
Solid Rocket Booster # 5 (righ     367    -0.60218D-01   0.26230D+01   0.49309D+00   0.88382D-01   0.13951D-01  -0.58750D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372    -0.22064D-01   0.14864D+00  -0.20905D+00   0.93496D-01  -0.21366D-01   0.82717D-02
Booster Gyro (right)               372    -0.22064D-01   0.14864D+00  -0.20905D+00   0.93496D-01  -0.21366D-01   0.82717D-02
Booster Gyro (right)               372    -0.22064D-01   0.14864D+00  -0.20905D+00   0.93496D-01  -0.21366D-01   0.82717D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.29359D-01  -0.88389D+00
IMU/ Accelerometer (right)        2322     0.00000D+00   0.29359D-01  -0.88389D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00   0.17907D-02   0.57875D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00   0.60063D-02  -0.93699D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00   0.17907D-02   0.57875D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE # 11/ 17, Frequency (rad/sec), Damping (zeta), Generalized Mass=    19.992       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088    -0.34243D-01   0.12247D+01   0.24834D-01   0.37190D-01  -0.10541D-02  -0.82136D-02
Shuttle Main Engine  # 2 (left    2254    -0.97664D-01   0.99292D+00  -0.14468D+00   0.39100D-01  -0.19918D-02  -0.15173D-01
Shuttle Main Engine  # 3 (righ    2091     0.42610D-01   0.10005D+01   0.20811D+00   0.34390D-01   0.12397D-01  -0.22628D-01
Solid Rocket Booster # 4 (left    1367     0.75819D+00  -0.67860D+00   0.29047D+00  -0.35992D-01   0.83078D-02   0.26005D-01
Solid Rocket Booster # 5 (righ     367    -0.75710D+00  -0.65701D+00  -0.31387D+00  -0.34250D-01  -0.89326D-02   0.25532D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372    -0.68757D+00   0.25209D+00   0.97284D-01  -0.45985D-01   0.29899D-01  -0.55162D-02
Booster Gyro (right)               372    -0.68757D+00   0.25209D+00   0.97284D-01  -0.45985D-01   0.29899D-01  -0.55162D-02
Booster Gyro (right)               372    -0.68757D+00   0.25209D+00   0.97284D-01  -0.45985D-01   0.29899D-01  -0.55162D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.33373D+01  -0.96311D-01
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.33373D+01  -0.96311D-01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.17178D+00   0.43940D-02   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.13893D+01  -0.16321D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.17178D+00   0.43940D-02   0.00000D+00   0.00000D+00   0.00000D+00

MODE #12/ 18, Frequency (rad/sec), Damping (zeta), Generalized Mass=    20.482       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.25368D+01  -0.11585D+00  -0.14977D+01   0.69168D-02  -0.81840D-01   0.58064D-03
Shuttle Main Engine  # 2 (left    2254     0.18525D+01  -0.15037D+00  -0.16759D+01   0.49554D-02  -0.86411D-01  -0.57557D-02
Shuttle Main Engine  # 3 (righ    2091     0.18564D+01  -0.16566D+00  -0.16770D+01   0.82380D-02  -0.13214D+00   0.75901D-02
Solid Rocket Booster # 4 (left    1367    -0.74671D-01  -0.70391D+00   0.13045D+01  -0.11705D-01   0.35881D-01   0.13422D-01
Solid Rocket Booster # 5 (righ     367    -0.10621D+00   0.72125D+00   0.13050D+01   0.19030D-01   0.35971D-01  -0.13313D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.29715D-02   0.27715D-01   0.27767D-02   0.61756D-04  -0.18222D-01  -0.53990D-03
Booster Gyro (right)               372     0.29715D-02   0.27715D-01   0.27767D-02   0.61756D-04  -0.18222D-01  -0.53990D-03
Booster Gyro (right)               372     0.29715D-02   0.27715D-01   0.27767D-02   0.61756D-04  -0.18222D-01  -0.53990D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.45454D-01   0.10076D+01
IMU/ Accelerometer (right)        2322     0.00000D+00   0.45454D-01   0.10076D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.38883D-02   0.53817D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.23400D-01   0.58087D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.38883D-02   0.53817D-01   0.00000D+00   0.00000D+00   0.00000D+00

MODE #13/ 19, Frequency (rad/sec), Damping (zeta), Generalized Mass=    21.541       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.23513D-01   0.71087D+00  -0.58004D-02   0.21546D-01  -0.14688D-02   0.23662D-01
Shuttle Main Engine  # 2 (left    2254    -0.19057D-02   0.69225D+00  -0.12139D+00   0.24067D-01  -0.95375D-02  -0.36752D-02
Shuttle Main Engine  # 3 (righ    2091     0.27435D-01   0.70000D+00   0.12368D+00   0.22223D-01   0.12954D-01  -0.10241D-01
Solid Rocket Booster # 4 (left    1367    -0.54232D+00  -0.18004D+00   0.44238D+00  -0.20387D-01   0.13103D-01   0.11634D-02
Solid Rocket Booster # 5 (righ     367     0.54058D+00  -0.14416D+00  -0.41363D+00  -0.18750D-01  -0.12286D-01   0.44884D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.41117D+00  -0.38480D+00  -0.70168D-01  -0.63008D-02  -0.32448D-02  -0.82751D-02
Booster Gyro (right)               372     0.41117D+00  -0.38480D+00  -0.70168D-01  -0.63008D-02  -0.32448D-02  -0.82751D-02
Booster Gyro (right)               372     0.41117D+00  -0.38480D+00  -0.70168D-01  -0.63008D-02  -0.32448D-02  -0.82751D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.43281D+01  -0.16969D+00
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.43281D+01  -0.16969D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00   0.28625D+00   0.24791D-02   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00   0.22203D+00   0.13753D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00   0.28625D+00   0.24791D-02   0.00000D+00   0.00000D+00   0.00000D+00

MODE #14/ 20, Frequency (rad/sec), Damping (zeta), Generalized Mass=    23.689       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088    -0.38945D-01  -0.21407D+01  -0.85695D-02  -0.29818D-02   0.62953D-02  -0.64960D-02
Shuttle Main Engine  # 2 (left    2254     0.15081D+00  -0.21259D+01   0.13473D+00  -0.27826D-01   0.29162D-01   0.33846D-01
Shuttle Main Engine  # 3 (righ    2091    -0.17784D+00  -0.21311D+01  -0.94546D-01  -0.19271D-01   0.75892D-02   0.41138D-01
Solid Rocket Booster # 4 (left    1367     0.19399D+00   0.41284D+00   0.79815D-01   0.14142D+00  -0.42751D-02  -0.11509D-01
Solid Rocket Booster # 5 (righ     367    -0.20649D+00   0.32578D+00  -0.11466D+00   0.13577D+00   0.31702D-02  -0.95375D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372    -0.75467D-01   0.11039D+01   0.69497D-01   0.14717D+00  -0.13788D-01   0.12282D-01
Booster Gyro (right)               372    -0.75467D-01   0.11039D+01   0.69497D-01   0.14717D+00  -0.13788D-01   0.12282D-01
Booster Gyro (right)               372    -0.75467D-01   0.11039D+01   0.69497D-01   0.14717D+00  -0.13788D-01   0.12282D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.47861D+01   0.22398D+00
IMU/ Accelerometer (right)        2322     0.00000D+00   0.47861D+01   0.22398D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.23628D+00  -0.73693D-02   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00   0.37458D+00   0.13144D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.23628D+00  -0.73693D-02   0.00000D+00   0.00000D+00   0.00000D+00

MODE #15/ 24, Frequency (rad/sec), Damping (zeta), Generalized Mass=    26.807       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088    -0.99888D+00   0.11457D-01   0.91668D+00   0.85622D-03   0.72881D-01  -0.37075D-02
Shuttle Main Engine  # 2 (left    2254    -0.44477D+00  -0.16681D-01   0.10202D+01   0.30538D-02   0.70027D-01   0.34051D-02
Shuttle Main Engine  # 3 (righ    2091    -0.45885D+00  -0.10098D-01   0.10915D+01  -0.15010D-02   0.12151D+00  -0.33239D-02
Solid Rocket Booster # 4 (left    1367     0.10451D+00   0.79056D-01   0.12859D+01  -0.52508D-01   0.51340D-01  -0.60871D-03
Solid Rocket Booster # 5 (righ     367     0.11974D+00  -0.12120D+00   0.12673D+01   0.55402D-01   0.50886D-01   0.22632D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.43116D+00   0.28726D+00   0.14082D+01   0.67135D-01  -0.66860D-01  -0.13148D-02
Booster Gyro (right)               372     0.43116D+00   0.28726D+00   0.14082D+01   0.67135D-01  -0.66860D-01  -0.13148D-02
Booster Gyro (right)               372     0.43116D+00   0.28726D+00   0.14082D+01   0.67135D-01  -0.66860D-01  -0.13148D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.62216D-02   0.13837D+01
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.62216D-02   0.13837D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00   0.16830D-01  -0.79862D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.41382D-01   0.15414D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00   0.16830D-01  -0.79862D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE #16/ 25, Frequency (rad/sec), Damping (zeta), Generalized Mass=    27.105       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088    -0.38017D-02   0.35340D+00  -0.30167D-01   0.94958D-01  -0.15007D-02  -0.61520D-01
Shuttle Main Engine  # 2 (left    2254     0.92148D-01  -0.59574D+00  -0.32915D+00   0.78460D-01   0.33245D-01   0.14576D-01
Shuttle Main Engine  # 3 (righ    2091    -0.17817D-01  -0.58626D+00   0.31394D+00   0.66757D-01   0.18085D-01   0.38549D-02
Solid Rocket Booster # 4 (left    1367    -0.33283D+00  -0.93011D+00   0.27213D+00   0.66527D-01   0.48931D-02   0.37693D-01
Solid Rocket Booster # 5 (righ     367     0.32834D+00  -0.98403D+00  -0.34987D+00   0.57772D-01  -0.81175D-02   0.38995D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.20764D+00  -0.94546D+00  -0.11638D+00   0.82751D-01  -0.71317D-02  -0.57328D-01
Booster Gyro (right)               372     0.20764D+00  -0.94546D+00  -0.11638D+00   0.82751D-01  -0.71317D-02  -0.57328D-01
Booster Gyro (right)               372     0.20764D+00  -0.94546D+00  -0.11638D+00   0.82751D-01  -0.71317D-02  -0.57328D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.57386D+00   0.17500D+00
IMU/ Accelerometer (right)        2322     0.00000D+00   0.57386D+00   0.17500D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00   0.77575D+00   0.14840D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.18923D+01  -0.18342D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00   0.77575D+00   0.14840D-01   0.00000D+00   0.00000D+00   0.00000D+00

MODE #17/ 28, Frequency (rad/sec), Damping (zeta), Generalized Mass=    30.578       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088    -0.52758D+00   0.16853D-01  -0.17895D+01   0.77546D-02  -0.12108D+00   0.56806D-02
Shuttle Main Engine  # 2 (left    2254    -0.12477D+01  -0.44575D-01  -0.18828D+01  -0.60190D-02  -0.84612D-01   0.86822D-02
Shuttle Main Engine  # 3 (righ    2091    -0.12400D+01  -0.20271D-01  -0.19839D+01   0.78156D-02  -0.18823D+00  -0.48268D-02
Solid Rocket Booster # 4 (left    1367     0.40786D+00  -0.10965D+00   0.88107D-01  -0.48684D-03   0.37700D-02   0.55896D-02
Solid Rocket Booster # 5 (righ     367     0.40720D+00   0.12555D+00   0.26046D-01   0.47304D-02   0.15391D-02  -0.61044D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.30031D+00  -0.70696D-01   0.39910D-01   0.17851D-01  -0.18756D-01  -0.71738D-02
Booster Gyro (right)               372     0.30031D+00  -0.70696D-01   0.39910D-01   0.17851D-01  -0.18756D-01  -0.71738D-02
Booster Gyro (right)               372     0.30031D+00  -0.70696D-01   0.39910D-01   0.17851D-01  -0.18756D-01  -0.71738D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.72530D-01   0.12839D+01
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.72530D-01   0.12839D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.29102D-02  -0.87080D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.48249D-03  -0.25094D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.29102D-02  -0.87080D-01   0.00000D+00   0.00000D+00   0.00000D+00

MODE #18/ 29, Frequency (rad/sec), Damping (zeta), Generalized Mass=    31.307       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088    -0.18993D-02   0.93207D-01  -0.32204D-01   0.39662D-01   0.59777D-03   0.51678D-01
Shuttle Main Engine  # 2 (left    2254     0.95815D-01  -0.23211D+00  -0.27133D+00   0.51796D-01  -0.16448D-01   0.21268D-01
Shuttle Main Engine  # 3 (righ    2091    -0.71572D-01  -0.22926D+00   0.19672D+00   0.49420D-01   0.29291D-02   0.18270D-01
Solid Rocket Booster # 4 (left    1367     0.14285D+00   0.16506D+00  -0.10641D+01  -0.92624D-02  -0.49410D-01  -0.58810D-02
Solid Rocket Booster # 5 (righ     367    -0.13836D+00   0.16039D+00   0.10687D+01  -0.11306D-01   0.49414D-01  -0.57785D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.25908D+00   0.40955D+00   0.21034D+01   0.28964D-01  -0.52523D-01   0.95674D-02
Booster Gyro (right)               372     0.25908D+00   0.40955D+00   0.21034D+01   0.28964D-01  -0.52523D-01   0.95674D-02
Booster Gyro (right)               372     0.25908D+00   0.40955D+00   0.21034D+01   0.28964D-01  -0.52523D-01   0.95674D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.10914D+01  -0.16854D+00
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.10914D+01  -0.16854D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.37862D+00  -0.29453D-02   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.21082D+00   0.41293D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.37862D+00  -0.29453D-02   0.00000D+00   0.00000D+00   0.00000D+00

MODE #19/ 31, Frequency (rad/sec), Damping (zeta), Generalized Mass=    33.056       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088    -0.32944D-01   0.24687D+01   0.23969D+00   0.49372D-02  -0.22762D-01  -0.79578D-01
Shuttle Main Engine  # 2 (left    2254    -0.10941D+00   0.21724D+01   0.29357D+00  -0.31514D-02   0.21672D-01   0.56923D-02
Shuttle Main Engine  # 3 (righ    2091    -0.11900D+00   0.22064D+01   0.19229D+00  -0.37386D-01   0.47772D-01  -0.32132D-01
Solid Rocket Booster # 4 (left    1367    -0.91772D-01   0.34252D-01   0.78541D-01   0.22090D-01  -0.26489D-02  -0.53303D-02
Solid Rocket Booster # 5 (righ     367     0.83024D-01   0.19372D-01  -0.11801D+00   0.33751D-01   0.26226D-02  -0.48343D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.18458D+00   0.68342D+00   0.58609D+00   0.59825D-01  -0.20760D-01   0.10593D-01
Booster Gyro (right)               372     0.18458D+00   0.68342D+00   0.58609D+00   0.59825D-01  -0.20760D-01   0.10593D-01
Booster Gyro (right)               372     0.18458D+00   0.68342D+00   0.58609D+00   0.59825D-01  -0.20760D-01   0.10593D-01

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.63250D+00   0.21357D+00
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.63250D+00   0.21357D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00   0.72367D-01   0.26157D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00   0.22496D+00   0.14397D-02   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00   0.72367D-01   0.26157D-01   0.00000D+00   0.00000D+00   0.00000D+00

MODE #20/ 32, Frequency (rad/sec), Damping (zeta), Generalized Mass=    33.964       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088    -0.32020D+00   0.88663D+00   0.14321D+01  -0.81928D-04  -0.21959D-02   0.11306D-01
Shuttle Main Engine  # 2 (left    2254    -0.35739D+00   0.74564D+00   0.13241D+01   0.13601D-01  -0.12473D-01   0.28843D-01
Shuttle Main Engine  # 3 (righ    2091    -0.58300D+00   0.76525D+00   0.15168D+01  -0.12006D-01   0.13084D+00   0.52949D-02
Solid Rocket Booster # 4 (left    1367     0.26421D-01  -0.36238D-01   0.34847D+00   0.15886D-01   0.16057D-01   0.12283D-02
Solid Rocket Booster # 5 (righ     367    -0.13820D-01  -0.31545D+00  -0.18045D+00   0.35974D-01  -0.30624D-03   0.10033D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.88235D-01   0.29200D+00   0.48868D+00   0.68083D-01  -0.20404D-01   0.63030D-03
Booster Gyro (right)               372     0.88235D-01   0.29200D+00   0.48868D+00   0.68083D-01  -0.20404D-01   0.63030D-03
Booster Gyro (right)               372     0.88235D-01   0.29200D+00   0.48868D+00   0.68083D-01  -0.20404D-01   0.63030D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.16782D+00   0.15503D+01
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.16782D+00   0.15503D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.25371D-01   0.27711D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00   0.12726D+00   0.67246D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.25371D-01   0.27711D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE #21/ 33, Frequency (rad/sec), Damping (zeta), Generalized Mass=    34.519       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.26902D-01   0.35188D+01   0.66281D-01   0.10330D-01  -0.50260D-01   0.32029D-01
Shuttle Main Engine  # 2 (left    2254     0.88939D-01   0.30174D+01  -0.36760D-01   0.24338D-01  -0.21180D-01   0.74874D-01
Shuttle Main Engine  # 3 (righ    2091    -0.49263D+00   0.30729D+01   0.98165D-01  -0.28458D-01   0.49355D-01   0.14951D-01
Solid Rocket Booster # 4 (left    1367     0.46340D-01  -0.65579D+00   0.63335D+00   0.63641D-01   0.17332D-01   0.20851D-01
Solid Rocket Booster # 5 (righ     367    -0.96579D-01  -0.66576D+00  -0.10407D+01   0.10084D+00  -0.32945D-01   0.21420D-01

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372    -0.34443D-01   0.62525D+00  -0.34123D+00   0.11712D+00  -0.10013D-01   0.57550D-02
Booster Gyro (right)               372    -0.34443D-01   0.62525D+00  -0.34123D+00   0.11712D+00  -0.10013D-01   0.57550D-02
Booster Gyro (right)               372    -0.34443D-01   0.62525D+00  -0.34123D+00   0.11712D+00  -0.10013D-01   0.57550D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.65650D+00  -0.34696D+00
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.65650D+00  -0.34696D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.96767D-01  -0.86222D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00   0.56423D+00  -0.49400D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.96767D-01  -0.86222D-01   0.00000D+00   0.00000D+00   0.00000D+00
MODE #22/ 34, Frequency (rad/sec), Damping (zeta), Generalized Mass=    35.498       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088    -0.30318D+00  -0.16937D+01   0.99652D+00  -0.98255D-02  -0.33476D-01  -0.15841D-01
Shuttle Main Engine  # 2 (left    2254    -0.91313D+00  -0.14398D+01   0.89323D+00  -0.11874D-01  -0.53227D-01  -0.28643D-01
Shuttle Main Engine  # 3 (righ    2091    -0.70942D+00  -0.14601D+01   0.94854D+00   0.58398D-02   0.43190D-01  -0.39227D-02
Solid Rocket Booster # 4 (left    1367    -0.10646D+00   0.63815D+00  -0.78736D+00  -0.76268D-01  -0.24536D-01  -0.22195D-01
Solid Rocket Booster # 5 (righ     367    -0.44027D-02   0.13292D+00  -0.10964D+00   0.12440D-01  -0.41581D-02  -0.41291D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372    -0.86481D-02   0.80565D-01  -0.96315D-01   0.11181D-01   0.23394D-02  -0.11250D-02
Booster Gyro (right)               372    -0.86481D-02   0.80565D-01  -0.96315D-01   0.11181D-01   0.23394D-02  -0.11250D-02
Booster Gyro (right)               372    -0.86481D-02   0.80565D-01  -0.96315D-01   0.11181D-01   0.23394D-02  -0.11250D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.31000D+00   0.79286D+00
IMU/ Accelerometer (right)        2322     0.00000D+00   0.31000D+00   0.79286D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00   0.69531D-01  -0.48298D-02   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.41072D+00  -0.62013D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00   0.69531D-01  -0.48298D-02   0.00000D+00   0.00000D+00   0.00000D+00

MODE #23/ 35, Frequency (rad/sec), Damping (zeta), Generalized Mass=    36.295       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.40459D+00  -0.14763D+00   0.54950D+00  -0.15817D-02   0.27566D-01  -0.85426D-02
Shuttle Main Engine  # 2 (left    2254     0.41402D+00  -0.10928D+00   0.51682D+00   0.26864D-02   0.61432D-02  -0.12754D-01
Shuttle Main Engine  # 3 (righ    2091     0.42872D+00  -0.13219D+00   0.60226D+00  -0.21461D-02   0.82596D-01   0.62428D-02
Solid Rocket Booster # 4 (left    1367     0.10992D+00   0.11266D-02  -0.24599D+00  -0.18260D-01  -0.10123D-01   0.44728D-03
Solid Rocket Booster # 5 (righ     367     0.14737D+00   0.18994D+00  -0.16801D+00   0.11291D-01  -0.76034D-02  -0.78228D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.64994D-01   0.57413D-01  -0.27385D+00   0.17020D-02  -0.56645D-04  -0.33797D-02
Booster Gyro (right)               372     0.64994D-01   0.57413D-01  -0.27385D+00   0.17020D-02  -0.56645D-04  -0.33797D-02
Booster Gyro (right)               372     0.64994D-01   0.57413D-01  -0.27385D+00   0.17020D-02  -0.56645D-04  -0.33797D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.24803D-01  -0.11839D+01
IMU/ Accelerometer (right)        2322     0.00000D+00   0.24803D-01  -0.11839D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00   0.24553D-01   0.12583D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.13430D+00   0.36349D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00   0.24553D-01   0.12583D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE #24/ 37, Frequency (rad/sec), Damping (zeta), Generalized Mass=    37.442       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.76582D+00  -0.14631D+00  -0.22464D+01   0.42452D-02  -0.62740D-02   0.11339D-01
Shuttle Main Engine  # 2 (left    2254     0.96496D+00  -0.81035D-01  -0.20776D+01  -0.13459D-01   0.21472D-01  -0.24127D-01
Shuttle Main Engine  # 3 (righ    2091     0.10320D+01  -0.12248D+00  -0.23549D+01   0.15532D-01  -0.21271D+00   0.22418D-01
Solid Rocket Booster # 4 (left    1367    -0.47666D-02  -0.10956D+00   0.42215D+00   0.36658D-01   0.17263D-01   0.44713D-02
Solid Rocket Booster # 5 (righ     367    -0.21894D-01   0.58799D-01   0.44840D+00  -0.38696D-01   0.18023D-01  -0.20471D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372    -0.22677D-02  -0.15509D+00   0.37667D+00  -0.27134D-01   0.27468D-02   0.60250D-04
Booster Gyro (right)               372    -0.22677D-02  -0.15509D+00   0.37667D+00  -0.27134D-01   0.27468D-02   0.60250D-04
Booster Gyro (right)               372    -0.22677D-02  -0.15509D+00   0.37667D+00  -0.27134D-01   0.27468D-02   0.60250D-04

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.32877D-01  -0.17050D+01
IMU/ Accelerometer (right)        2322     0.00000D+00   0.32877D-01  -0.17050D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.12436D-01  -0.14564D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00   0.60787D-01   0.56718D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.12436D-01  -0.14564D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE #25/ 42, Frequency (rad/sec), Damping (zeta), Generalized Mass=    45.687       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088    -0.69721D+00   0.86952D-02  -0.29544D+00   0.10504D-01  -0.17825D-01   0.87456D-02
Shuttle Main Engine  # 2 (left    2254    -0.53236D+00  -0.11396D+00  -0.22356D+00   0.24083D-02   0.23287D-01   0.15601D-01
Shuttle Main Engine  # 3 (righ    2091    -0.56539D+00  -0.87458D-01  -0.25947D+00   0.13151D-01  -0.69950D-01  -0.28992D-02
Solid Rocket Booster # 4 (left    1367     0.18956D-01  -0.22788D-01  -0.92049D+00  -0.47189D-01  -0.45652D-01   0.91966D-03
Solid Rocket Booster # 5 (righ     367     0.20266D-01   0.96937D-02  -0.90802D+00   0.46610D-01  -0.45012D-01  -0.35027D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.25123D+00   0.11286D+00   0.54824D+00   0.17645D-01  -0.50568D-01   0.94544D-03
Booster Gyro (right)               372     0.25123D+00   0.11286D+00   0.54824D+00   0.17645D-01  -0.50568D-01   0.94544D-03
Booster Gyro (right)               372     0.25123D+00   0.11286D+00   0.54824D+00   0.17645D-01  -0.50568D-01   0.94544D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.11279D+00   0.51278D+00
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.11279D+00   0.51278D+00

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.64813D-02  -0.23399D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.38795D-02   0.87490D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.64813D-02  -0.23399D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE #26/ 50, Frequency (rad/sec), Damping (zeta), Generalized Mass=    48.610       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.44332D+00  -0.76243D-01   0.12966D+01  -0.11190D-01  -0.35530D-01   0.77468D-02
Shuttle Main Engine  # 2 (left    2254    -0.12217D-01   0.18331D-01   0.11017D+01   0.14168D-01  -0.60520D-01  -0.96941D-03
Shuttle Main Engine  # 3 (righ    2091     0.57323D-01   0.14347D-01   0.12055D+01   0.33612D-02  -0.39469D-02  -0.11347D-01
Solid Rocket Booster # 4 (left    1367    -0.25431D-01   0.39886D+00  -0.18013D+00   0.70672D-03  -0.59874D-02  -0.17633D-01
Solid Rocket Booster # 5 (righ     367     0.16305D-01  -0.43785D-01  -0.49823D+00  -0.24883D-02  -0.23245D-01   0.23070D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.69723D-01   0.33177D+00   0.42159D+00   0.53650D-01  -0.12662D-01   0.18620D-02
Booster Gyro (right)               372     0.69723D-01   0.33177D+00   0.42159D+00   0.53650D-01  -0.12662D-01   0.18620D-02
Booster Gyro (right)               372     0.69723D-01   0.33177D+00   0.42159D+00   0.53650D-01  -0.12662D-01   0.18620D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.33148D+00  -0.17647D+01
IMU/ Accelerometer (right)        2322     0.00000D+00   0.33148D+00  -0.17647D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.36111D+00   0.20845D+00   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.10939D+01   0.38758D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.36111D+00   0.20845D+00   0.00000D+00   0.00000D+00   0.00000D+00

MODE #27/ 70, Frequency (rad/sec), Damping (zeta), Generalized Mass=    56.971       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.31294D-01  -0.40544D-01   0.17039D+01  -0.11862D-01   0.13120D-01  -0.32723D-01
Shuttle Main Engine  # 2 (left    2254    -0.19841D+00  -0.85045D-02   0.15871D+01   0.32801D-02  -0.16891D-02   0.53982D-03
Shuttle Main Engine  # 3 (righ    2091    -0.20535D+00  -0.25859D-01   0.16324D+01   0.14726D-02   0.61547D-01   0.37492D-02
Solid Rocket Booster # 4 (left    1367    -0.97747D-02   0.34022D-01  -0.50545D-01  -0.81761D-02  -0.23161D-02  -0.11594D-02
Solid Rocket Booster # 5 (righ     367    -0.17035D-01  -0.38862D-01  -0.50466D-01  -0.74686D-02  -0.22067D-02   0.13225D-02

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.18147D+00   0.27699D+00   0.92335D+00   0.46290D-01  -0.29789D-01   0.27168D-02
Booster Gyro (right)               372     0.18147D+00   0.27699D+00   0.92335D+00   0.46290D-01  -0.29789D-01   0.27168D-02
Booster Gyro (right)               372     0.18147D+00   0.27699D+00   0.92335D+00   0.46290D-01  -0.29789D-01   0.27168D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.26744D+01  -0.40045D+01
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.26744D+01  -0.40045D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00   0.29302D-02  -0.71270D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00   0.12772D+00  -0.37648D+00   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00   0.29302D-02  -0.71270D-01   0.00000D+00   0.00000D+00   0.00000D+00

MODE #28/ 71, Frequency (rad/sec), Damping (zeta), Generalized Mass=    57.153       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.20110D+00  -0.30830D-01  -0.13774D+01  -0.95080D-02  -0.97721D-02  -0.32477D-01
Shuttle Main Engine  # 2 (left    2254     0.19430D+00   0.24118D+00  -0.11543D+01  -0.39148D-01   0.18904D-02  -0.30073D-01
Shuttle Main Engine  # 3 (righ    2091     0.37011D+00   0.22290D+00  -0.15038D+01  -0.13109D-01  -0.93412D-01  -0.43994D-03
Solid Rocket Booster # 4 (left    1367     0.11680D-01  -0.49585D-01   0.46986D-01  -0.11034D-01   0.22103D-02   0.20286D-02
Solid Rocket Booster # 5 (righ     367     0.17574D-03   0.86657D-02   0.37627D-01  -0.80747D-02   0.18416D-02  -0.24379D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372     0.53529D-01  -0.12301D+00   0.30140D+00  -0.14990D-01  -0.88176D-02   0.35194D-03
Booster Gyro (right)               372     0.53529D-01  -0.12301D+00   0.30140D+00  -0.14990D-01  -0.88176D-02   0.35194D-03
Booster Gyro (right)               372     0.53529D-01  -0.12301D+00   0.30140D+00  -0.14990D-01  -0.88176D-02   0.35194D-03

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.43917D+01   0.36731D+01
IMU/ Accelerometer (right)        2322     0.00000D+00  -0.43917D+01   0.36731D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00  -0.36018D-02   0.27431D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00   0.92691D-01   0.40645D-01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00  -0.36018D-02   0.27431D-01   0.00000D+00   0.00000D+00   0.00000D+00

MODE #29/ 95, Frequency (rad/sec), Damping (zeta), Generalized Mass=    65.686       0.50000E-02   0.12000E+06
DEFINITION OF LOCATIONS (NODES)            phi along X   phi along Y   phi along Z   sigm about X  sigm about Y  sigm about Z

                              Node ID#     Modal Data at the  5 Engines, (x,y,z)...
Shuttle Main Engine  # 1          2088     0.14203D+00   0.59439D+00  -0.19324D+01  -0.46535D-01  -0.15319D-01  -0.45565D-01
Shuttle Main Engine  # 2 (left    2254     0.30886D+00   0.10938D+01  -0.13583D+01  -0.93937D-01   0.18618D-01  -0.38839D-01
Shuttle Main Engine  # 3 (righ    2091     0.48095D+00   0.10947D+01  -0.21500D+01  -0.34876D-01  -0.11836D+00   0.13099D-03
Solid Rocket Booster # 4 (left    1367     0.97530D-02   0.17959D-01  -0.81033D-02  -0.19670D-01   0.34043D-03  -0.62718D-03
Solid Rocket Booster # 5 (righ     367     0.31747D-01  -0.38837D-02  -0.48110D-02   0.22465D-01   0.87800D-05   0.44306D-03

                              Node ID#     Modal Data at the  3 Gyros ...
Booster Gyro (right)               372    -0.59076D-01  -0.15645D-01  -0.50991D+00  -0.34682D-01   0.50839D-02   0.27536D-02
Booster Gyro (right)               372    -0.59076D-01  -0.15645D-01  -0.50991D+00  -0.34682D-01   0.50839D-02   0.27536D-02
Booster Gyro (right)               372    -0.59076D-01  -0.15645D-01  -0.50991D+00  -0.34682D-01   0.50839D-02   0.27536D-02

                              Node ID#     Modal Data at the  2 Accelerometers, along (x,y,z)...
IMU/ Accelerometer (right)        2322     0.00000D+00   0.36805D+01  -0.53248D+01
IMU/ Accelerometer (right)        2322     0.00000D+00   0.36805D+01  -0.53248D+01

                              Node ID#     Modal Data at the  2 Slosh Masses...
LOX Slosh Mass                     238     0.00000D+00   0.72320D-02   0.28448D-01   0.00000D+00   0.00000D+00   0.00000D+00
LH2 Slosh Mass                     239     0.00000D+00  -0.15553D+00   0.10554D+01   0.00000D+00   0.00000D+00   0.00000D+00

                              Node ID#     Modal Data at the Disturbance Point 
LOX Slosh Mass                     238     0.00000D+00   0.72320D-02   0.28448D-01   0.00000D+00   0.00000D+00   0.00000D+00
----------------------------------------------------------------------------------------------------------------------------
TRANSFORM A SYSTEM (S-Z-W) ..... (New z-system title, Comments, Old s-system title, Transform)
Shuttle Ascent, Max_Q, T=55 sec, Flex Vehicle with Slosh and TWD, Z-transform
! Transform the above vehicle model to Discrete using the 
! S to Z Transformation method and 40 msec Sampling Period
!
Shuttle Ascent, Max_Q, T=55 sec, Flex Vehicle with Slosh and TWD
From S-plane to Z-plane using the Z-Transform, dT= 0.04
----------------------------------------------------------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ HYDRAULIC TYPE B
Shuttle Main Engine Actuator
! Shuttle Main Engine Actuator Without Compensator 
! Using the Hydraulic Actuator Model Type (B)
Symbol       Parameter Description               (Units)     Value
C(s)   Order of Compensat:(0,1,2), Coefficients   (---)      0
Kav    Total Gain of Amplifier + Torque Motor  (ft-lb/rad)  0.91000
Kact   Power Valve and Actuator Gain .........(ft/s/ft-lb)   53.950
Kt     Piston Ram Stiffness ...................  (lb/ft)    0.20280E+07
R      Moment Arm of Actuator Ram from Gimbal    (feet)      2.4800
Ie     Engine Inertia about Gimbal ............(ft-lb-s^2)   4516.0
Be     Engine Viscous Damping .................(ft-lb-sec)   16500.
Kb     Engine Gimbal Bearing Spring Constant   (ft-lb/rad)   27160.0
Kl     Engine Mount Structural Stiffness ......  (lb/ft)    0.27960E+07
Tc     Different. Pressure Feedbk Time Constant  (seconds)  0.12660
Kdpf   Differ Pressure Feedbk Linearizat. Gain  (ft-lb/lb)  0.40400E-06
Kfb    Position Feedback Gain ................. (rad/feet)  0.4
-----------------------------------------------------------------------------
ACTUATOR INPUT DATA ............ HYDRAULIC TYPE B
Solid Rocket Booster Actuator
Symbol       Parameter Description               (Units)     Value
C(s)   Order of Compensat:(0,1,2), Coefficients   (---)      0
Kav    Total Gain of Amplifier + Torque Motor  (ft-lb/rad)   1.8152
Kact   Power Valve and Actuator Gain .........(ft/s/ft-lb)   75.4
Kt     Piston Ram Stiffness ...................  (lb/ft)    0.45000E+07
R      Moment Arm of Actuator Ram from Gimbal    (feet)      5.8
Ie     Engine Inertia about Gimbal ............(ft-lb-s^2)   11000.0
Be     Engine Viscous Damping .................(ft-lb-sec)   17166.0
Kb     Engine Gimbal Bearing Spring Constant   (ft-lb/rad)  0.19166E+06
Kl     Engine Mount Structural Stiffness ......  (lb/ft)    0.60000E+07
Tc     Different. Pressure Feedbk Time Constant  (seconds)  0.1252
Kdpf   Differ Pressure Feedbk Linearizat. Gain  (ft-lb/lb)  0.40000E-06
Kfb    Position Feedback Gain ................. (rad/feet)  0.172
---------------------------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
System of Five Actuators
! A Combination of 5 actuators in parallel, 3 Space Shuttle Main Engine actuators,
! and 2 Solid Rocket Booster actuatots
!
Titles of Systems to be Combined
Title 1 Shuttle Main Engine Actuator
Title 2 Shuttle Main Engine Actuator
Title 3 Shuttle Main Engine Actuator
Title 4 Solid Rocket Booster Actuator
Title 5 Solid Rocket Booster Actuator
SYSTEM INPUTS TO SUBSYSTEM  1                                                           SSME Engine # 1
System Input  1 to Subsystem  1, Input  1, Gain= 1.00000                                Command Input
System Input  6 to Subsystem  1, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                                           SSME Engine # 2
System Input  2 to Subsystem  2, Input  1, Gain= 1.00000                                Command Input
System Input  7 to Subsystem  2, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                                           SSME Engine # 3
System Input  3 to Subsystem  3, Input  1, Gain= 1.00000                                Command Input
System Input  8 to Subsystem  3, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  4                                                           SRB Engine # 4
System Input  4 to Subsystem  4, Input  1, Gain= 1.00000                                Command Input
System Input  9 to Subsystem  4, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  5                                                           SRB Engine # 5
System Input  5 to Subsystem  5, Input  1, Gain= 1.00000                                Command Input
System Input 10 to Subsystem  5, Input  2, Gain= 1.00000                                Load-Torque
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                                        SSME Engine # 1
System Output  1 from Subsystem  1, Output  1, Gain= 1.00000                            Deflection
System Output  6 from Subsystem  1, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                                        SSME Engine # 2
System Output  2 from Subsystem  2, Output  1, Gain= 1.00000                            Deflection
System Output  7 from Subsystem  2, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                                        SSME Engine # 3
System Output  3 from Subsystem  3, Output  1, Gain= 1.00000                            Deflection
System Output  8 from Subsystem  3, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  4                                                        SRB Engine # 4
System Output  4 from Subsystem  4, Output  1, Gain= 1.00000                            Deflection
System Output  9 from Subsystem  4, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  5                                                        SRB Engine # 5
System Output  5 from Subsystem  5, Output  1, Gain= 1.00000                            Deflection
System Output 10 from Subsystem  5, Output  3, Gain= 1.00000                            Acceleration
..............................................................................
Definitions of Inputs  =  10
SSME Engine # 1 delta command (rad)   
SSME Engine # 2 delta command (rad)                                                              
SSME Engine # 3 delta command (rad)                                                              
SRB  Engine # 4 delta command (rad)                                                              
SRB  Engine # 5 delta command (rad)                                                              
SSME Engine # 1 Load-Torque (ft-lb)    
SSME Engine # 2 Load-Torque (ft-lb)    
SSME Engine # 3 Load-Torque (ft-lb)    
SRB  Engine # 4 Load-Torque (ft-lb)    
SRB  Engine # 5 Load-Torque (ft-lb)    
 
Definitions of Outputs =  10
SSME Engine # 1 deflection (rad)   
SSME Engine # 2 deflection (rad)   
SSME Engine # 3 deflection (rad)   
SRB  Engine # 4 deflection (rad)   
SRB  Engine # 5 deflection (rad)   
SSME Engine # 1 accelerat. (rad/sec^2)   
SSME Engine # 2 accelerat. (rad/sec^2)   
SSME Engine # 3 accelerat. (rad/sec^2)   
SRB  Engine # 4 accelerat. (rad/sec^2)   
SRB  Engine # 5 accelerat. (rad/sec^2)   
----------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
IMU, Gyro, Accelerometer Sensors
! Flight Control Sensor Dynamics (Low-Pass Filters)
Continuous
TF. Block #  1 IMU-roll                                          Order of Numer, Denom=  1  1
Numer 0.0         7.0
Denom 1.0         7.0
TF. Block #  2 IMU-pitch                                         Order of Numer, Denom=  1  1
Numer 0.0         7.0
Denom 1.0         7.0
TF. Block #  3 IMU-yaw                                           Order of Numer, Denom=  1  1
Numer 0.0         7.0
Denom 1.0         7.0
TF. Block #  4 Rate Gyro Roll                                    Order of Numer, Denom=  1  1
Numer 0.0         60.0
Denom 1.0         60.0
TF. Block #  5 Rate Gyro Pitch                                   Order of Numer, Denom=  1  1
Numer 0.0         60.0
Denom 1.0         60.0
TF. Block #  6 Rate Gyro Yaw                                     Order of Numer, Denom=  1  1
Numer 0.0         60.0
Denom 1.0         60.0
TF. Block #  7 Acceleromet-Ydd                                   Order of Numer, Denom=  2  2
Numer 0.0         0.0         225.0
Denom 1.0         20.5        225.0
TF. Block #  8 Acceleromet-Zdd                                   Order of Numer, Denom=  2  2
Numer 0.0         0.0         225.0
Denom 1.0         20.5        225.0
......................................................
Block #, from Input #, Gain
 1       1        1.0                                            IMU
 2       2        1.0                                            IMU
 3       3        1.0                                            IMU
 4       4        1.0                                            Gyro
 5       5        1.0                                            Gyro
 6       6        1.0                                            Gyro
 7       7        1.0                                            Accelerom
 8       8        1.0                                            Accelerom
...........................
Outpt #, from Block #, Gain
 1       1        1.0                                            IMU
 2       2        1.0                                            IMU
 3       3        1.0                                            IMU
 4       4        1.0                                            Gyro
 5       5        1.0                                            Gyro
 6       6        1.0                                            Gyro
 7       7        1.0                                            Accelerom
 8       8        1.0                                            Accelerom
...........................
Definitions of Inputs  =   8
Roll IMU Input
Pitch IMU Input
Yaw IMU Input
Roll Rate Gyro Input
Pitch Rate Gyro Input
Yaw Rate Gyro Input
Y-ddot Accelerometer Input
Z-ddot Accelerometer Input
 
Definitions of Outputs =   8
Roll IMU Output
Pitch IMU Output
Yaw IMU Output
Roll Rate Gyro Output
Pitch Rate Gyro Output
Yaw Rate Gyro Output
Y-ddot Accelerometer Output
Z-ddot Accelerometer Output
----------------------------------------------------------------------------------------------------------------------------
TRANSFORM A SYSTEM (S-Z-W) ..... (New z-system title, Comments, Old s-system title, Transform)
System of Five Actuators, Z-Transform
! Z-Transform the 5 actuators subsystem using 40 msec sample rate
System of Five Actuators
From S-plane to Z-plane using the Z-Transform, dT= 0.04
----------------------------------------------------------------------------------------------------------------------------
TRANSFORM A SYSTEM (S-Z-W) ..... (New z-system title, Comments, Old s-system title, Transform)
IMU, Gyro, Accelerometer Sensors, Z-transform
! Z-Transform the Sensors subsystem at 40 msec
IMU, Gyro, Accelerometer Sensors
From S-plane to Z-plane using the Z-Transform, dT= 0.04
----------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Pitch Axis Discrete FCS
! Shuttle Ascent Pitch Axis, First Stage Discrete Flight Control System at Max-Q
!
Discrete, Dt= 0.04
TF. Block #  1 Loop Roll-Off                                     Order of Numer, Denom=  2  2
Numer 0.1503906  -0.0351563   0.0097656
Denom 1.000000   -1.5         0.625
TF. Block #  2 Rate Gyro Flex                                    Order of Numer, Denom=  2  2
Numer 0.3999056  -0.4957601   0.3126082
Denom 1.00000    -1.403368    0.6201218
TF. Block #  3 Nz/q-gyro Lead-Lag                                Order of Numer, Denom=  1  1
Numer 1.00       -1.0
Denom 1.00000    -0.9607843
TF. Block #  4 Nz LAG                                            Order of Numer, Denom=  1  1
Numer 0.0196078   0.0196078
Denom 1.00000    -0.9607843
TF. Block #  5 Nz Accelerom Flex                                 Order of Numer, Denom=  2  2
Numer 0.3070985  -0.419753    0.2376543
Denom 1.00000    -1.5         0.625
TF. Block #  6 Stage-1 Flex                                      Order of Numer, Denom=  2  2
Numer 0.5154625  -0.8864844   0.4788288
Denom 1.00000    -1.7157517   0.8235586
TF. Block #  7 Stage-1 Lead-Lag                                  Order of Numer, Denom=  1  1
Numer 1.3820038  -1.0422583
Denom 1.00000    -0.6602564
......................................................
Block #, from Input #, Gain
 2       1     0.24                                              KM-Theta
 2       2     1.00000                                           q-Gyro
 3       2     0.013                                             KM-QHP
 4       3     1.00000                                           Nz
...........................
Block #, from Block #, Gain
 1       7     1.00000
 7       6     1.00000
 6       2     1.00000
 6       5     29.5                                              KM-NZ
 5       3     1.00000
 5       4     1.00000
...........................
Outpt #, from Block #, Gain
 1       1     1.0                                               DQ-TVC
...........................
Definitions of Inputs  =   3
Pitch Attitude, Theta (rad)
Pitch Rate, q (rad/sec)
Normal Acceleration, Nz (ft/sec^2)
 
Definitions of Outputs =   1
Flight Control Output DQ_TVC
---------------------------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Lateral Axes Discrete FCS (Roll/Yaw)
! Shuttle Ascent Lateral Axes, First Stage Discrete Flight Control System at Max-Q
!
Discrete, dt=  0.04
TF. Block #  1 Integrator                                        Order of Numer, Denom=  0  1
Numer .04         0.0
Denom 1.00000    -1.00000
TF. Block #  2 SRB Yaw Gyro Flex-(A)                             Order of Numer, Denom=  2  2
Numer .2467115   -0.3241875  0.2088816
Denom 1.00000    -1.4259120  0.5573177
TF. Block #  3 SRB Yaw Gyro Flex-(B)                             Order of Numer, Denom=  2  2
Numer .6165192   -1.0724472  0.5880485
Denom 1.00000    -1.7221789  0.8542994
TF. Block #  4 Yaw Loop Lead-Lag                                 Order of Numer, Denom=  1  1
Numer 1.501434   -1.436794
Denom 1.00000    -0.935359
TF. Block #  5 Yaw Loop Roll-Off                                 Order of Numer, Denom=  2  2
Numer .3397436   -0.1153846  0.1858974
Denom 1.00000    -1.0769231  0.4871795
TF. Block #  6 Ny/p-gyro Lead-Lag                                Order of Numer, Denom=  1  1
Numer 1.00000    -1.00000
Denom 1.00000    -0.9607843
TF. Block #  7 Accelerom Flex-(A)                                Order of Numer, Denom=  2  2
Numer .2081466   -0.3232571   0.1955714
Denom 1.00000    -1.7931855   0.8736464
TF. Block #  8 Accelerom Flex-(B)                                Order of Numer, Denom=  2  2
Numer .4156536   -0.7033374   0.3806493
Denom 1.00000    -1.4874218   0.5803873
TF. Block #  9 Ny Accelerom Lag                                  Order of Numer, Denom=  1  1
Numer .0196078    0.0196078
Denom 1.00000    -0.9607843
TF. Block # 10 p-orb-gyro Lead-Lag                               Order of Numer, Denom=  1  1
Numer 1.6727572  -1.5848026
Denom 1.00000    -.9120459
TF. Block # 11 Roll Gyro Flex-(a)                                Order of Numer, Denom=  2  2
Numer 0.4545326  -0.7825079  0.4414405
Denom 1.00000    -1.7957624  0.9092276
TF. Block # 12 Roll Gyro Flex-(b)                                Order of Numer, Denom=  2  2
Numer 0.155868   -0.2309941  0.1347129
Denom 1.00000    -1.6049615  0.6645483
TF. Block # 13 Roll Loop Roll-Off                                Order of Numer, Denom=  2  2
Numer 0.3573574   0.1501502   0.033033
Denom 1.00000    -0.8108108   0.3513514
......................................................
Block #, from Input #, Gain
  1  1    0.3                                                         psi-error
  2  1    0.3                                                         psi-err to yaw rg flex filtr
  2  3    1.0                                                         yaw-rate-error (srb)
  6  3    1.0
  6  4   -0.68                                                        roll-rate-err  (orb)
 10  1   -0.95                                                        psi-err to roll loop
 10  2    0.77                                                        phi-error
 10  4    1.0                                                         p-orb to LL filtr
  9  5    1.0                                                         Ny to Ny_Lag Filtr
...........................
Block #, from Block #, Gain
  3  2    1.00000                                                     yaw srb gyro flex filtr
